# Allegro board LA-G716P r0.1.brd (continued)
## Routing (per net, layer and track width the routed paths; a pad name or vN(x,y) marks a point on that pad's centre or on a via; arc(x,y) is an arc through that point) (continued)
TPM_ID: length 10.8
  BOTTOM w0.076: UC1.CK25 121.3,50.45 121.07,50.22 121.07,49.08 121.17,48.98 121.17,48.68
  BOTTOM w0.089: 121.17,48.68 121.17,47.91 120.77,47.51 120.77,47.21
  BOTTOM w0.112: 120.77,47.21 120.77,46.15 119.95,45.34 RC59.2 119.97,44.84 120.41,44.4 120.41,42.84 120.05,42.48 RC63.1 119.55,41.78 v1(119.17,41.4)
TPM_SPI_IRQ#: length 62.3
  TOP w0.112: v2(80.56,36.18) 81.17,36.18 82.08,37.08 RX1.2 82.08,38 82.29,38.21 83.24,38.21 83.45,38.01 83.45,37.3 83.87,36.87 UX1.18
  IN3 w0.135: v2(123.86,53.29) 122.59,53.29 118.89,49.59 114.08,49.59 113.32,50.35 113.06,50.35 112.67,49.95 112.67,48.45 111.91,47.7 111.91,47 111.12,46.21 111.12,45.86 106.46,41.2 93.88,41.2 92.97,40.29 90.35,40.29 87.71,37.65 85.25,37.65 84.74,37.14 84.74,34.85 84.36,34.47 81.9,34.47 80.56,35.8 v2(80.56,36.18)
  BOTTOM w0.076: UC1.CF20 123.96,53.19 v2(123.86,53.29)
TPS25810_EN: length 45.1
  TOP w0.112: UE1.89 40.15,84.56 v2(40.02,84.69) ; v2(35.34,113.28) v1(34.68,113.28)
  IN1 w0.119: v2(35.34,113.28) 35.59,113.03 35.59,90.37 36.14,89.82 36.14,87.98 38.93,85.19 39.61,85.19 40.02,84.78 v2(40.02,84.69)
  IN3 w0.135: v2(35.34,113.28) 30.32,113.28 28.23,115.37 v2(26.77,115.37)
  BOTTOM w0.112: RT9.1 26.64,115.5 v2(26.77,115.37) 28.36,115.37 28.5,115.52 UT1.6
TPS25810_POL#: length 53.7
  TOP w0.112: v2(22.64,115.88) 22.77,116.01 QT1.2 23.58,116.01 24.13,115.46 v1(24.13,114.74) ; UE1.91 39.35,84.69 v2(39.44,84.78)
  IN1 w0.119: v2(32.59,117.77) 32.42,117.6 32.42,114.36 33.46,113.32 33.46,98.33 35.37,96.42 35.37,90.28 35.92,89.73 35.92,87.89 39.03,84.78 v2(39.44,84.78)
  IN3 w0.135: v2(32.59,117.77) 31.68,118.68 28.48,118.68 26.91,117.1 23.86,117.1 v2(22.64,115.88)
  BOTTOM w0.112: RT10.1 32.61,117.79 v2(32.59,117.77) 32.48,117.66 UT1.18
TPS25810_UFP#: length 64.4
  TOP w0.112: v2(32.93,117.16) v1(33.46,117.16) ; v2(48.93,70.67) 49.75,69.85 UE1.32
  IN1 w0.119: v2(48.93,70.67) 48.17,71.43 48.17,78.85 48.75,79.43 48.75,81.66 46.5,83.91 45.17,83.91 43.11,85.97 38.46,85.97 36.36,88.08 36.36,89.91 35.81,90.46 35.81,99.69 36.84,100.72 36.84,114.26 33.94,117.16 v2(32.93,117.16)
  BOTTOM w0.112: RT11.1 33.61,117.03 33.48,117.16 v2(32.93,117.16) UT1.19
TS_EN: length 4.1
  TOP w0.112: v2(213.3,41.47) 213.3,42.05 213.53,42.29 v1(213.53,42.54) 213.39,42.68 R14.1 C18.1
  BOTTOM w0.112: v2(213.3,41.47) 213.28,41.45 JEDP1.39
TSENSE_1PH_CPU: length 5.3
  TOP w0.112: v2(171.19,58.62) 171.14,58.57 170.18,58.57 v1(169.62,59.13)
  TOP w0.254: PCZ36.1 PRZ63.1 171.45,59.11 171.19,58.86 v2(171.19,58.62)
  BOTTOM w0.203: PUZ01.23 172,57.7 171.45,58.25 171.45,58.36 v2(171.19,58.62)
TSENSE_1PH_CPU_R: length 52.5
  TOP w0.254: PRZ65.1 173.03,59.44 PRZ63.2 172.7,59.55 172.44,59.81 170.74,59.81 v1(170.71,59.84) 170.54,60.01 v2(170.54,60.32)
  IN2 w0.254: v2(170.54,60.32) 169.2,61.65 169.2,62.03 165.87,65.36 165.87,68.03 164.21,69.69 164.21,72.14 166,73.94 166,83.63 166.59,84.22 166.59,87.35 166.4,87.54 166.4,93.92 163.7,96.63 158.1,96.63 v2(157.39,97.34)
  BOTTOM w0.254: PHZ05.1 157.2,97.15 v2(157.39,97.34)
TSENSE_2PH_CPU: length 3.9
  TOP w0.112: v2(173.48,51.67) 173.77,51.38 v1(174.19,51.38)
  TOP w0.254: PRZ34.2 173,52.32 PCZ22.1 173.69,51.87 v2(173.48,51.67)
  BOTTOM w0.203: PUZ01.11 173.63,51.81 v2(173.48,51.67)
TSENSE_2PH_CPU_R: length 2.8
  TOP w0.112: PRZ34.1 v1(171.79,50.97)
  TOP w0.254: PHZ04.1 171.79,52.9 PRZ36.1 PRZ34.1
TYPEC_CC1: length 27.6
  TOP w0.279: JUSBC1.A5 8.29,121.82 v2(8.34,121.88)
  IN3 w0.508: v2(8.92,124.26) 8.95,124.26 10.26,122.96 10.26,122.24 9.9,121.88 v2(8.34,121.88)
  BOTTOM w0.254: 28.05,119.49 28.25,119.49 28.5,119.24 UT1.11
  BOTTOM w0.508: v2(8.92,124.26) 9,124.19 EU11.2 15.81,124.19 18.35,121.65 v1(22.58,121.65) 25.89,121.65 28.05,119.49
TYPEC_CC2: length 32.6
  TOP w0.279: v2(6.57,120.37) 6.37,120.57 JUSBC1.B5
  IN3 w0.508: v2(8.23,125.76) 8.23,124.57 7.21,123.55 7.21,120.84 6.74,120.37 v2(6.57,120.37)
  BOTTOM w0.254: 29.12,120.39 29.5,120.01 UT1.13
  BOTTOM w0.508: 29.12,120.39 25.78,123.73 v1(19.71,123.73) 18.58,123.73 16.19,126.12 EU11.3 10.88,126.55 8.74,126.55 8.23,126.04 v2(8.23,125.76)
UART1_CTS#: length 1.8
  TOP w0.102: 128,53.21 v2(128.08,53.12)
  TOP w0.112: TP27.1 127.8,53.41 128,53.21
  BOTTOM w0.076: v2(128.08,53.12) 128.09,53.12 128.13,53.12 128.56,52.71 UC1.CG14
UART1_RTS#: length 1.2
  TOP w0.112: TP26.1 129.07,53.06 v2(129.01,53)
  BOTTOM w0.076: v2(129.01,53) 129.04,53.02 129.05,53.01 UC1.CF12
UG1_CHG: length 10.8
  TOP w0.112: v2(201.08,44.45) v1(200.57,44.45)
  IN3 w0.762: 200.22,44.51 193.07,44.51 191.68,45.91 190.47,45.91
  vias: v2(189.14,45.78) v2(189.72,45.78) v2(201.52,44.83)
UG1_VGA: length 12.4
  TOP w0.112: v2(90.25,122.84) v1(90.8,122.84)
  IN3 w0.762: 89.95,123.53 85.84,123.53 85.2,122.89 ; 83.17,122.89 81.34,124.72 80.3,124.72 78,127.01
  vias: v2(77.65,127.63) v2(84.03,123.05) v2(84.46,122.6) v2(89.67,122.84)
UG2_VGA: length 9.5
  TOP w0.112: PQV03.1 v1(89.03,138.7)
  IN3 w0.762: 78.25,131.8 79.85,133.4 79.85,133.79 81.21,135.15 81.21,135.91 82.55,137.25 83.64,137.25
  vias: v2(77.55,131.7) v2(84.4,137.56) v2(84.4,136.95) v2(89.73,137.35) v2(89.73,136.76)
UG_1.2V: length 7.3
  TOP w0.112: v2(44.03,29.23) v1(44.03,29.75)
  IN1 w0.635: v2(44.03,29.23) 43.99,29.23 43.9,29.14 41.33,29.14 40.55,29.93 39.49,29.93 38.66,29.1 38.66,28.4
  vias: v2(39.26,28.14)
UG_VCCSA: length 5.9
  TOP w0.112: v2(160.88,55.68) v1(160.27,55.68)
  IN1 w0.508: v2(166.15,53.96) 162.92,53.96 161.45,55.43
USB2_COMP: length 11.2
  TOP w0.089: v2(134.05,54.15) 134.25,54.15 134.75,54.65 135.51,54.65 135.52,54.64 135.54,54.64
  TOP w0.112: 135.54,54.64 v1(136.2,54.64) 139.48,54.64 139.81,54.96 143.12,54.96 143.29,54.8 RC123.1
  BOTTOM w0.112: UC1.CC5 v2(134.05,54.15)
USB2_ID: length 2.4
  TOP w0.089: v1(132.69,53.7) 132.62,53.7 132.19,53.27
  TOP w0.112: RC124.1 131.9,52.97 v2(132.15,53.22) 132.15,53.23 132.19,53.27
  BOTTOM w0.102: UC1.CE8 131.9,53.46 v2(132.15,53.22)
USB2_VBUSSENSE: length 12.1
  TOP w0.089: 135.54,55.13 134.86,55.13 134.4,54.67 133.95,54.67 v2(133.42,54.14)
  TOP w0.112: 135.54,55.13 139.28,55.13 139.6,55.46 v1(142.08,55.46) 142.53,55.46 142.63,55.56 RC125.1
  BOTTOM w0.102: v2(133.42,54.14) 133.2,54.36 UC1.CC6
USB3_1_MRX_DTX_N4: length 20.6
  TOP w0.102: JUSBC1.B10 6.46,123.07 6.47,123.08 v2(6.49,123.08)
  TOP w0.112: UT2.3 22.44,124.37 22.57,124.5 22.57,125.29 22.36,126.01 22.21,126.19 22,126.38 22,126.38 21.8,126.57 21.02,126.91 18.21,126.91 16.57,126.56 15.25,125.77 14.99,125.77 14.74,125.53 EU8.8 EU8.2 13.1,125.53 12.98,125.64 11.89,125.64 11.45,125.21 9.93,125.21 v2(9.72,125.01)
  BOTTOM w0.112: v2(9.72,125.01) 9.54,125.19 8.93,125.19 7.08,123.33 6.73,123.33 v2(6.49,123.08)
USB3_1_MRX_DTX_P4: length 20.9
  TOP w0.112: v2(6.49,123.72) 6.34,123.57 JUSBC1.B11 ; v2(9.72,125.59) 9.88,125.43 11.36,125.43 11.79,125.87 12.89,125.87 13.05,126.03 EU8.1 EU8.9 14.81,126.03 14.84,125.99 15.19,125.99 16.49,126.77 18.18,127.13 21.06,127.13 21.89,126.77 21.92,126.76 22.37,126.34 22.55,126.12 22.79,125.32 22.79,124.44 22.84,124.4 UT2.2
  BOTTOM w0.112: v2(9.72,125.59) 9.54,125.41 8.84,125.41 6.99,123.55 6.65,123.55 v2(6.49,123.72)
USB3_1_MTX_C_DRX_N4: length 10.5
  TOP w0.112: JUSBC1.A3 7.35,122.83 7.79,122.83 8.02,123.05 8.85,123.05 9.12,123.32 9.14,123.32 9.51,123.7 9.51,123.72 9.96,124.17 v4(12.07,124.17) 12.93,124.17 13.07,124.03 EU8.5 EU8.6 14.93,124.03 15.07,124.17 15.38,124.17 15.9,123.65 16.45,123.65 CT8.2
USB3_1_MTX_C_DRX_P4: length 10.4
  TOP w0.112: JUSBC1.A2 7.4,123.32 8.09,123.32 8.14,123.27 8.76,123.27 v4(9.16,123.67) 9.87,124.39 11.79,124.39 11.81,124.4 12.34,124.4 12.35,124.39 12.93,124.39 13.07,124.53 EU8.4 EU8.7 14.93,124.53 15.07,124.39 15.47,124.39 15.99,123.87 16.45,123.87 CT7.2
USB3_1_MTX_DRX_N4: length 4.1
  TOP w0.112: UT2.7 20.81,122.93 20.72,123.02 v4(20.07,123.02) 19.18,123.02 18.92,123.28 18.9,123.28 18.53,123.65 18.04,123.65 CT8.1
USB3_1_MTX_DRX_P4: length 4.1
  TOP w0.112: UT2.6 20.81,123.33 20.72,123.24 20.35,123.24 20.34,123.25 19.81,123.25 19.8,123.24 19.27,123.24 v4(18.88,123.63) 18.64,123.87 18.03,123.87 CT7.1
USB3_2_MRX_DTX_N4: length 17.8
  TOP w0.112: UT2.8 20.91,122.53 20.83,122.45 20.74,122.45 20.63,122.42 20.42,122.31 20.34,122.24 20.09,121.93 20.03,121.62 20.03,118.92 19.4,118.29 18.42,118.29 18.42,118.29 18.33,118.29 15.37,118.77 15.27,118.78 15.07,118.78 14.93,118.91 EU9.9 EU9.1 13.07,118.91 12.96,118.8 v4(12.11,118.8) 10.63,118.8 10.61,118.82 9.86,118.82 9.54,119.14 7.96,119.14 7.78,119.32 JUSBC1.A10
USB3_2_MRX_DTX_P4: length 17.9
  TOP w0.112: UT2.9 20.96,122.13 20.86,122.23 20.74,122.23 20.53,122.12 20.3,121.83 20.25,121.6 20.25,118.83 19.49,118.07 18.29,118.07 15.34,118.55 15.07,118.55 14.94,118.41 EU9.8 EU9.2 13.07,118.41 12.9,118.58 12.39,118.58 12.38,118.57 11.85,118.57 11.83,118.58 v4(10.35,118.58) 9.78,118.58 9.45,118.92 7.98,118.92 7.89,118.83 7.35,118.83 JUSBC1.A11
USB3_2_MTX_C_DRX_N4: length 12.6
  TOP w0.112: v2(9.76,117.84) 9.94,117.66 11.34,117.66 11.72,117.28 13.11,117.28 13.25,117.41 EU9.4 EU9.7 15.08,117.41 15.22,117.28 16.72,117.28 CT10.2 ; v2(6.58,119.42) 6.43,119.58 5.75,119.58 JUSBC1.B3
  BOTTOM w0.112: v2(6.58,119.42) 6.83,119.17 7.38,119.17 8.89,117.66 9.58,117.66 v2(9.76,117.84)
USB3_2_MTX_C_DRX_P4: length 12.6
  TOP w0.112: JUSBC1.B2 5.75,119.07 6.31,119.07 v2(6.54,118.84) ; CT9.2 16.57,117.05 15.22,117.05 15.08,116.91 EU9.6 EU9.5 13.23,116.91 13.09,117.05 11.63,117.05 11.25,117.44 9.94,117.44 v2(9.76,117.26)
  BOTTOM w0.112: v2(9.76,117.26) 9.58,117.44 8.8,117.44 7.29,118.95 6.65,118.95 v2(6.54,118.84)
USB3_2_MTX_DRX_N4: length 9.5
  TOP w0.112: UT2.11 22.44,121.42 22.6,121.25 22.6,119.29 22.59,119.27 22.59,118.74 22.6,118.73 22.6,117.94 22.17,117.5 20.83,117.5 20.2,116.87 v4(19.35,116.87) 18.65,116.87 18.5,117.01 18.5,117.09 18.06,117.53 CT10.1
USB3_2_MTX_DRX_P4: length 9.5
  TOP w0.112: UT2.12 22.84,121.42 22.82,121.4 v4(22.82,119.01) 22.82,117.84 22.26,117.28 20.93,117.28 20.29,116.64 19.63,116.64 19.62,116.63 19.08,116.63 19.07,116.64 CT9.1
USB3_CRX_C_MTX_N4: length 2.4
  TOP w0.112: CT4.2 25.45,123.92 25.3,123.92 24.73,123.35 24.39,123.35 24.37,123.33 UT2.17
USB3_CRX_C_MTX_P4: length 2.4
  TOP w0.112: CT5.2 25.61,124.14 25.21,124.14 24.64,123.57 24.48,123.57 24.32,123.73 UT2.18
USB3_CRX_DTX_N1: length 141.6
  TOP w0.112: RU6.2 23.38,57.03 LU3.3 23.9,57.2 24.02,57.32 v4(24.65,57.32) 25.64,57.32 26.28,56.69 28.34,56.69 29.15,57.5 30.21,57.5 v2(30.39,57.31)
  IN1 w0.089: 131.61,49.46 131.62,49.48 131.62,49.5 131.83,49.71 134.39,49.71 134.77,50.08 134.77,52.46 134.6,52.63 134.6,54.68 134.4,54.88 134.12,54.88 134.03,54.97 v2(134.03,55.06)
  IN1 w0.119: v2(30.39,57.31) 30.57,57.5 30.93,57.5 31.35,57.08 31.35,53.46 36.45,48.36 41.21,48.36 45.09,44.49 51.44,44.49 52.51,45.56 57.86,45.56 58.94,44.48 62.79,44.48 64.26,43.02 64.89,43.02 68.2,39.71 70.26,39.71 73.47,36.49 80.08,36.49 81.67,38.08 83.31,38.08 83.5,38.27 84.07,38.27 84.55,37.79 88.54,37.79 89.97,36.36 93.49,36.36 94.53,37.4 98.34,37.4 99.65,36.09 110.87,36.09 111.34,35.62 114.84,35.62 117.54,38.32 118.56,38.32 118.94,37.94 124.51,37.94 125.6,39.03 125.6,39.27 126.77,40.44 126.77,42.55 129.68,45.46 129.68,47.54 131.61,49.46
  BOTTOM w0.102: UC1.CB5 133.85,55.24 134.02,55.06 v2(134.03,55.06)
USB3_CRX_DTX_N2: length 139.7
  TOP w0.112: v2(50.07,45.28) 49.83,45.53 46.9,45.53 41.31,39.94 36.06,39.94 35.71,39.58 34.53,39.58 31.31,36.35 31.31,35 29.98,33.67 27.8,33.67 24.65,30.51 v4(23.66,30.51) 22.67,30.51 22.58,30.42 LU6.3 22.05,30.42 RU12.2
  IN1 w0.089: v2(132.12,56.01) 131.95,55.84 131.95,55.67 131.72,55.43 129.94,55.43 129.45,54.94 129.45,53.53 129.65,53.32 129.65,49.53 129.59,49.46
  IN1 w0.119: 129.59,49.46 128.89,48.76 128.01,48.76 127.05,47.81 127.05,45.04 125.38,43.37 125.38,41.02 124.43,40.06 123.14,40.06 122.08,39 120.61,39 120.59,39.02 117.33,39.02 114.58,36.26 111.6,36.26 111.12,36.74 102.26,36.74 100.96,38.04 94.26,38.04 94.11,37.89 90.04,37.89 89.5,38.43 85.11,38.43 84.63,38.91 83.23,38.91 83.04,38.72 81.37,38.72 79.78,37.13 74.66,37.13 74.15,37.65 73.23,37.65 70.53,40.35 68.47,40.35 65.09,43.73 65.09,44.42 63.96,45.56 59.19,45.56 57.95,46.79 52.68,46.79 51.16,45.28 v2(50.07,45.28)
  BOTTOM w0.102: v2(132.12,56.01) 131.9,56.24 UC1.BY8
USB3_CRX_DTX_P1: length 141.7
  TOP w0.112: v2(30.39,57.9) 30.21,57.72 29.06,57.72 28.25,56.91 26.37,56.91 25.74,57.54 24.94,57.54 24.93,57.55 24.38,57.55 24.37,57.54 24.02,57.54 23.87,57.7 LU3.2 23.38,57.86 RU4.2
  IN1 w0.089: 131.45,49.62 131.47,49.63 131.49,49.63 131.75,49.9 134.31,49.9 134.59,50.18 134.59,52.39 134.42,52.55 134.42,54.6 134.34,54.69 133.76,54.69 133.61,54.83 133.61,54.84 133.39,55.06 v2(133.39,55.07)
  IN1 w0.119: v2(30.39,57.9) 30.57,57.72 31.02,57.72 31.57,57.17 31.57,53.55 36.54,48.58 41.3,48.58 45.18,44.71 51.35,44.71 52.42,45.78 57.95,45.78 59.03,44.7 62.88,44.7 64.35,43.24 64.98,43.24 68.29,39.93 70.35,39.93 73.57,36.71 79.99,36.71 81.58,38.3 83.22,38.3 83.41,38.49 84.16,38.49 84.64,38.01 88.63,38.01 90.06,36.58 93.4,36.58 94.44,37.62 98.43,37.62 99.74,36.3 110.96,36.3 111.43,35.84 114.75,35.84 117.45,38.54 118.65,38.54 119.03,38.16 124.42,38.16 125.38,39.12 125.38,39.36 126.55,40.53 126.55,42.64 129.46,45.55 129.46,47.63 131.45,49.62
  BOTTOM w0.102: UC1.CB6 133.42,55.31 133.42,55.1 v2(133.39,55.07)
USB3_CRX_DTX_P2: length 139.6
  TOP w0.112: RU10.2 22.05,30.92 LU6.2 22.58,30.92 22.77,30.73 23.38,30.73 23.39,30.75 23.92,30.75 23.94,30.73 24.56,30.73 27.71,33.89 29.88,33.89 31.09,35.09 31.09,36.44 34.44,39.8 35.61,39.8 35.97,40.16 41.22,40.16 46.81,45.75 49.95,45.75 v2(50.07,45.87)
  IN1 w0.089: 129.43,49.62 129.44,49.62 129.46,49.62 129.48,49.64 129.48,53.25 129.26,53.46 129.26,55 129.87,55.61 131.64,55.61 131.77,55.74 131.77,55.92 131.68,56.01 v2(131.51,56.01)
  IN1 w0.119: v2(50.07,45.87) 50.33,45.61 50.34,45.61 50.44,45.5 51.07,45.5 52.59,47.01 58.04,47.01 59.28,45.78 64.05,45.78 65.31,44.51 65.31,43.82 68.56,40.57 70.62,40.57 73.32,37.86 74.24,37.86 74.75,37.35 79.69,37.35 81.28,38.94 82.95,38.94 83.14,39.13 84.72,39.13 85.2,38.65 89.59,38.65 90.13,38.11 94.02,38.11 94.17,38.26 101.05,38.26 102.35,36.96 111.21,36.96 111.7,36.48 114.48,36.48 117.24,39.24 120.68,39.24 120.7,39.22 121.99,39.22 123.05,40.28 124.34,40.28 125.16,41.11 125.16,43.46 126.84,45.13 126.84,47.9 127.92,48.98 128.8,48.98 129.43,49.62
  BOTTOM w0.102: UC1.BY9 131.26,56.45 v2(131.51,56.01)
USB3_CRX_L_DTX_N1: length 15.5
  TOP w0.112: JUSB1.5 14.38,49.93 14.49,50.04 15.06,50.04 15.52,50.49 15.52,51.55 15.2,51.87 15.2,52.43 15.39,52.62 15.39,53.68 15.16,53.91 15.16,54.48 17.46,56.78 17.77,57.08 17.77,57.1 18.03,57.37 v4(18.05,57.37) 18.33,57.65 18.72,57.65 18.83,57.53 EU1.9 EU1.1 20.39,57.53 20.53,57.67 20.94,57.67 21.28,57.34 21.88,57.34 22.02,57.2 LU3.4 22.47,57.03 RU6.1
USB3_CRX_L_DTX_N2: length 11.4
  TOP w0.112: JUSB2.5 14.38,25.96 14.55,26.13 15.05,26.13 15.82,26.89 16.25,26.89 17.37,28 17.37,28.46 17.38,28.47 17.38,29 17.37,29.01 v4(17.37,30.25) 17.37,30.83 17.48,30.94 17.64,30.94 17.77,30.81 EU3.9 EU3.1 19.48,30.81 19.62,30.94 19.71,30.94 20.09,30.56 20.33,30.56 20.47,30.42 LU6.4 20.87,30.42 RU12.1
USB3_CRX_L_DTX_P1: length 15.5
  TOP w0.112: JUSB1.6 14.38,50.37 14.49,50.26 14.97,50.26 15.29,50.58 15.29,51.46 14.98,51.78 14.98,52.52 15.17,52.71 15.17,53.59 14.94,53.81 14.94,54.57 17.37,57 17.55,57.17 17.55,57.19 17.61,57.26 18.22,57.87 18.69,57.87 18.86,58.03 EU1.8 EU1.2 20.39,58.03 20.53,57.89 21.05,57.89 v4(21.22,57.73) 21.39,57.56 21.92,57.56 22.06,57.7 LU3.1 22.47,57.86 RU4.1
USB3_CRX_L_DTX_P2: length 11.4
  TOP w0.112: RU10.1 20.88,30.92 LU6.1 20.48,30.92 20.34,30.78 20.18,30.78 19.8,31.16 19.6,31.16 19.46,31.31 EU3.2 EU3.8 17.77,31.31 17.63,31.16 17.39,31.16 17.15,30.92 17.15,30.53 17.14,30.52 17.14,29.99 17.15,29.97 v4(17.15,28.74) 17.15,28.1 16.16,27.11 15.72,27.11 14.96,26.35 14.61,26.35 14.38,26.57 JUSB2.6
USB3_CRX_MTX_N4: length 174
  TOP w0.112: v2(27.64,123.34) 27.19,123.79 27.07,123.79 CT4.1
  IN3 w0.089: v2(133.51,56.94) 133.65,56.79 133.65,56.67 133.55,56.56 133.27,56.56 133.26,56.57 132.51,56.57 132.5,56.56 130.6,56.56 130.46,56.7 130.46,58.8 130.65,58.99 131.25,58.99 132.88,60.61 132.88,60.9 133.69,61.72 134.21,61.72 134.68,62.19 134.68,65.62 134.78,65.72
  IN3 w0.135: 134.78,65.72 134.78,67.3 134.67,67.41 134.67,68.38 134.78,68.49 134.78,69.27 134.67,69.39 134.67,70.34 134.73,70.4 134.73,72.72 134.68,72.77 134.68,73.36 134.81,73.49 134.81,79 135.71,79.9 135.71,85.2 135.05,85.86 135.05,91.04 134.1,91.99 132.72,91.99 131.64,93.08 131.64,94.31 128.78,97.17 128.78,104.19 128.13,104.84 128.13,107.14 126.28,108.99 126.28,109.8 121.61,114.47 108.04,114.47 107.23,115.28 105.4,115.28 105.14,115.01 82.78,115.01 82.26,115.53 79.43,115.53 78.35,116.61 74.99,116.61 74.66,116.94 71.91,116.94 71.58,116.61 68.19,116.61 67.61,117.2 55.94,117.2 55.01,118.13 38.65,118.13 33.87,122.91 27.04,122.91 26.83,123.12 26.83,123.63 27.03,123.83 27.8,123.83 27.97,123.66 27.97,123.47 27.84,123.34 v2(27.64,123.34)
  BOTTOM w0.109: UC1.BW6 v2(133.51,56.94)
USB3_CRX_MTX_P4: length 174
  TOP w0.112: v2(27.59,124.26) 27.34,124.01 27.16,124.01 CT5.1
  IN3 w0.089: v2(134.1,56.92) 134.1,56.87 133.62,56.39 133.27,56.39 133.26,56.37 133.19,56.37 133.18,56.38 132.58,56.38 132.57,56.37 130.52,56.37 130.27,56.62 130.27,58.88 130.58,59.18 131.2,59.18 132.69,60.67 132.69,60.98 133.61,61.91 134.15,61.91 134.5,62.26 134.5,65.69 134.56,65.75 134.56,65.78
  IN3 w0.135: 134.56,65.78 134.56,67.21 134.45,67.32 134.45,68.48 134.56,68.59 134.56,69.18 134.44,69.3 134.44,70.44 134.5,70.5 134.5,72.63 134.45,72.68 134.45,73.45 134.59,73.59 134.59,78.67 134.57,78.69 134.57,78.7 134.57,78.7 134.57,78.71 134.57,79.1 135.47,80 135.47,85.1 134.81,85.76 134.81,90.94 134,91.75 132.62,91.75 131.39,92.98 131.39,94.21 128.54,97.07 128.54,104.09 127.89,104.74 127.89,107.04 126.04,108.89 126.04,109.7 121.51,114.23 107.94,114.23 107.13,115.04 105.5,115.04 105.24,114.77 82.68,114.77 82.16,115.29 79.33,115.29 78.25,116.37 74.89,116.37 74.56,116.7 72.01,116.7 71.68,116.37 68.09,116.37 67.51,116.96 55.84,116.96 54.91,117.89 38.55,117.89 33.77,122.67 26.94,122.67 26.59,123.02 26.59,123.73 26.93,124.07 27.4,124.07 v2(27.59,124.26)
  BOTTOM w0.109: UC1.BW5 v2(134.1,56.92)
USB3_CTX_C_DRX_N1: length 1.6
  TOP w0.112: RU5.2 23.38,58.87 LU2.3 23.78,59.04 23.92,59.18 24.23,59.18 CU2.2
USB3_CTX_C_DRX_N2: length 1.6
  TOP w0.112: CU15.2 23.1,32.23 22.75,32.58 22.4,32.58 22.26,32.44 LU5.3 21.93,32.44 RU11.2
USB3_CTX_C_DRX_P1: length 1.6
  TOP w0.112: RU3.2 23.38,59.7 LU2.2 23.75,59.54 23.88,59.4 24.23,59.4 CU1.2
USB3_CTX_C_DRX_P2: length 1.6
  TOP w0.112: RU9.2 21.92,32.94 LU5.2 22.27,32.94 22.41,32.8 22.77,32.8 CU14.2
USB3_CTX_C_MRX_N4: length 2.2
  TOP w0.112: CT3.2 25.58,122.2 25.58,122.2 25.09,122.2 24.84,122.44 24.56,122.44 24.47,122.53 UT2.15
USB3_CTX_C_MRX_P4: length 2.2
  TOP w0.112: CT2.2 25.48,121.98 24.99,121.98 24.75,122.22 24.56,122.22 24.47,122.13 UT2.14
USB3_CTX_DRX_N1: length 145.9
  TOP w0.112: v2(27.95,58.25) 27.95,58.35 27.77,58.53 27.74,58.53 27.73,58.54 26.96,58.54 26.33,59.18 25.94,59.18 CU2.1
  IN1 w0.089: 135.04,52.08 134.97,52.02
  IN1 w0.119: 135.04,52.08 135.77,52.81 135.77,53.6 137.21,55.03 137.44,55.03 137.85,55.44 137.85,55.58 v2(137.66,55.78) ; v2(27.95,58.25) 28.11,58.25 28.23,58.37 28.23,58.57 28.08,58.71 27.59,58.71 27.47,58.59 27.47,56.75 36.28,47.94 41.04,47.94 44.91,44.06 51.79,44.06 52.61,44.89 54.41,44.89 55.54,43.76 58.72,43.76 58.9,43.94 62.26,43.94 63.48,42.72 63.48,41.94 63.96,41.46 65.85,41.46 69.57,37.74 70.97,37.74 72.65,36.07 76.98,36.07 77.59,35.46 80.52,35.46 82.48,37.42 83.45,37.42 84.49,36.38 89.35,36.38 89.79,35.94 97.88,35.94 98.24,35.58 110.77,35.58 111.19,35.17 115.18,35.17 115.56,35.55 116.04,35.55 116.96,36.47 118.43,36.47 119.41,37.45 124.62,37.45 126.61,39.44 127.66,39.44 128.75,40.53 128.75,43.41 130.83,45.49 130.83,47.81 132.51,49.49 134.25,49.49 134.27,49.46 134.42,49.46 134.97,50.02 134.97,52.02
  BOTTOM w0.076: 137.85,56.11 137.84,56.13 137.83,56.13 137.76,56.19 137.06,56.19 136.76,55.89 136.43,55.89 136.33,55.93 136.11,55.93 136.02,55.89 135.76,55.89 135.42,56.04 135.32,56.06 135.15,56.06 UC1.CA4
  BOTTOM w0.102: v2(137.66,55.78) 137.85,55.97 137.85,56.11
USB3_CTX_DRX_N2: length 146.6
  TOP w0.112: v2(53.01,43.01) 52.23,43.01 51.88,43.36 51.88,45.56 50.47,46.98 49.56,46.98 48.87,46.29 46.76,46.29 41.04,40.57 35.8,40.57 35.44,40.22 34.22,40.22 28.31,34.3 27.42,34.3 25.69,32.57 24.35,32.57 CU15.1
  IN1 w0.119: v2(53.01,43.01) 53.29,43.01 53.35,42.95 54.46,42.95 54.81,42.61 60.43,42.61 62.44,40.6 64.71,40.6 66.89,38.42 67.67,38.42 69.34,36.75 70.75,36.75 72.29,35.21 76.21,35.21 76.92,34.5 94.61,34.5 94.83,34.72 110.41,34.72 110.83,34.31 115.54,34.31 115.92,34.69 116.46,34.69 117.39,35.61 118.79,35.61 119.77,36.59 124.98,36.59 126.97,38.58 128.02,38.58 130.15,40.71 130.15,43.6 131.69,45.14 131.69,45.86 132.24,46.41 132.24,47.38 133.47,48.61 133.91,48.61 133.92,48.6 134.78,48.6 135.84,49.66 135.84,51.66 136.63,52.46 136.63,53.24 137.56,54.17 137.8,54.17 138.55,54.92 138.96,54.92 139.33,55.29 139.33,55.74 v2(139.47,55.87)
  BOTTOM w0.102: v2(139.47,55.87) 139.47,56.61 139.18,56.89 138.64,56.89 138.53,56.78 136.18,56.78 136,56.6 136,56.42 UC1.CA2
USB3_CTX_DRX_P1: length 146
  TOP w0.112: CU1.1 25.94,59.4 26.42,59.4 27.06,58.76 27.48,58.76 v2(27.85,59.13)
  IN1 w0.119: v2(27.85,59.13) 27.65,58.93 27.49,58.93 27.25,58.68 27.25,56.66 36.19,47.72 40.95,47.72 44.82,43.85 51.88,43.85 52.7,44.67 54.32,44.67 55.45,43.54 58.81,43.54 58.99,43.72 62.17,43.72 63.26,42.63 63.26,41.85 63.86,41.24 65.76,41.24 69.48,37.52 70.88,37.52 72.55,35.85 76.89,35.85 77.5,35.24 80.61,35.24 82.57,37.2 83.36,37.2 84.4,36.16 89.26,36.16 89.7,35.72 97.79,35.72 98.15,35.37 110.68,35.37 111.1,34.95 115.28,34.95 115.66,35.33 116.13,35.33 117.05,36.25 118.52,36.25 119.5,37.23 124.71,37.23 126.7,39.22 127.75,39.22 128.96,40.44 128.96,43.32 131.05,45.4 131.05,47.72 132.6,49.27 134.16,49.27 134.18,49.24 134.51,49.24 135.19,49.93 135.19,51.92 135.99,52.72 135.99,53.51 137.3,54.81 137.53,54.81 138.07,55.35 138.07,55.58 v2(138.27,55.78)
  BOTTOM w0.076: 138.04,56.18 138.04,56.18 137.93,56.29 137.89,56.29 137.83,56.36 137,56.36 136.69,56.06 136.46,56.06 136.36,56.09 136.08,56.09 135.99,56.06 135.8,56.06 135.6,56.14 135.57,56.21 135.57,56.39 135.49,56.47 135.38,56.47 135.25,56.33 UC1.CA3
  BOTTOM w0.102: 138.04,56.18 138.04,55.88 138.15,55.78 v2(138.27,55.78)
USB3_CTX_DRX_P2: length 146.5
  TOP w0.112: v2(53.01,43.6) 52.64,43.23 52.32,43.23 52.1,43.45 52.1,45.65 50.56,47.2 49.46,47.2 48.77,46.51 46.67,46.51 40.95,40.8 35.71,40.8 35.35,40.44 34.13,40.44 28.22,34.52 27.33,34.52 25.6,32.79 24.35,32.79 CU14.1
  IN1 w0.119: v2(138.86,55.87) 139.11,55.62 139.11,55.38 138.87,55.14 138.46,55.14 137.71,54.39 137.47,54.39 136.41,53.33 136.41,52.55 135.62,51.75 135.62,49.75 134.69,48.82 134.01,48.82 134,48.83 133.38,48.83 132.02,47.47 132.02,46.5 131.48,45.95 131.48,45.23 129.93,43.69 129.93,40.8 127.93,38.8 126.88,38.8 124.89,36.81 119.68,36.81 118.7,35.83 117.3,35.83 116.37,34.91 115.83,34.91 115.45,34.53 110.92,34.53 110.51,34.94 94.74,34.94 94.52,34.72 77.01,34.72 76.3,35.42 72.38,35.42 70.84,36.97 69.44,36.97 67.76,38.64 66.98,38.64 64.8,40.82 62.53,40.82 60.52,42.82 54.9,42.82 54.55,43.17 53.44,43.17 53.18,43.43 53.18,43.43 v2(53.01,43.6)
  BOTTOM w0.102: UC1.CA1 136.54,56.31 136.29,56.31 136.19,56.42 136.19,56.52 136.26,56.59 138.61,56.59 138.72,56.7 139.1,56.7 139.27,56.53 139.27,56.32 139.17,56.22 138.92,56.22 138.82,56.12 138.82,55.91 v2(138.86,55.87)
USB3_CTX_L_DRX_N1: length 11
  TOP w0.112: RU5.1 22.47,58.87 LU2.4 21.99,59.04 21.86,59.17 21.48,59.17 21.47,59.16 20.9,59.16 20.89,59.17 20.5,59.17 20.36,59.03 EU1.4 EU1.7 18.81,59.03 18.67,59.17 v4(17.74,59.17) 17.12,59.17 15.32,57.38 15.32,57.19 15.28,57.01 15.21,56.77 15.2,56.74 15.2,56.39 14.85,56.04 14.49,56.04 14.38,55.93 JUSB1.8
USB3_CTX_L_DRX_N2: length 8.1
  TOP w0.112: JUSB2.8 14.38,32.03 14.49,32.14 14.65,32.14 14.66,32.13 15.08,32.13 15.5,31.71 16.32,31.71 17.04,32.44 17.65,32.44 17.77,32.31 EU3.7 EU3.4 19.46,32.31 19.6,32.45 19.85,32.45 19.97,32.57 20.23,32.57 20.36,32.44 LU5.4 20.74,32.44 RU11.1
USB3_CTX_L_DRX_P1: length 11
  TOP w0.112: JUSB1.9 14.38,56.37 14.49,56.26 14.76,56.26 14.98,56.48 14.98,56.75 14.99,56.82 15.07,57.07 15.1,57.22 15.1,57.47 17.03,59.4 17.42,59.4 17.43,59.41 18.04,59.41 18.05,59.4 18.73,59.4 18.87,59.53 EU1.6 EU1.5 20.35,59.53 20.49,59.4 v4(21.2,59.4) 21.87,59.4 22.01,59.54 LU2.1 22.47,59.71 RU3.1
USB3_CTX_L_DRX_P2: length 8.1
  TOP w0.112: RU9.1 20.75,32.94 LU5.1 20.34,32.94 20.2,32.79 19.88,32.79 19.76,32.67 19.62,32.67 19.48,32.81 EU3.5 EU3.6 17.77,32.81 17.63,32.67 v4(17.23,32.67) 16.96,32.67 16.23,31.94 15.59,31.94 15.18,32.35 14.75,32.35 14.74,32.36 14.49,32.36 14.38,32.47 JUSB2.9
USB3_CTX_MRX_N4: length 176.2
  TOP w0.112: CT3.1 27.23,122.04 47.55,122.04 47.55,122.04 56.11,122.04 56.93,121.22 60.23,121.22 61.83,119.62 61.83,119.06 v2(62.02,118.87)
  IN1 w0.119: v2(137.11,95.99) 136.93,95.81 134.15,95.81 131,98.96 130.07,98.96 121.93,107.1 120.15,107.1 117.97,109.29 108.04,109.29 106.01,111.32 95.97,111.32 92.52,114.77 88.78,114.77 86.81,116.74 82.49,116.74 79.7,119.53 77.67,119.53 75.98,121.22 73.23,121.22 71.94,119.93 69.4,119.93 68.14,118.67 68.14,118 67.13,116.99 62.61,116.99 61.85,117.75 61.85,118.69 v2(62.02,118.87)
  IN3 w0.135: v2(138.69,57.6) 138.69,57.84 138.95,58.1 139.48,58.1 140.37,58.99 140.7,58.99 143.13,61.41 143.3,61.41 143.88,61.99 143.88,62.8 142.48,64.19 141,64.19 140.5,64.7 140.5,65.2 140.5,65.2 140.5,65.73 140.5,65.73 140.5,66.35 139.86,66.99 139.86,75.96 140.23,76.33 140.23,78.23 140.99,78.98 140.99,80.03 140.99,86.61 140.18,87.42 140.18,92.75 138.01,94.93 138.01,95.57 137.73,95.84 137.26,95.84 v2(137.11,95.99)
  BOTTOM w0.076: UC1.BW2 135.97,57.37 135.97,57.13 136.14,56.95 138.36,56.95 138.59,57.18 138.59,57.49 v2(138.69,57.6)
USB3_CTX_MRX_P4: length 176.2
  TOP w0.112: CT2.1 27,121.82 47.51,121.82 47.51,121.82 56.02,121.82 56.84,121 60.14,121 61.61,119.52 61.61,119.04 v2(61.44,118.87)
  IN1 w0.119: v2(61.44,118.87) 61.63,118.68 61.63,117.66 62.52,116.77 67.23,116.77 68.36,117.91 68.36,118.58 69.49,119.71 72.03,119.71 73.32,121 75.89,121 77.58,119.31 79.61,119.31 82.4,116.52 86.72,116.52 88.69,114.55 92.43,114.55 95.88,111.1 105.92,111.1 107.95,109.07 117.88,109.07 120.06,106.88 121.84,106.88 129.98,98.74 130.91,98.74 134.06,95.59 136.44,95.59 136.56,95.47 136.56,95.32 136.64,95.23 136.94,95.23 v2(137.11,95.41)
  IN3 w0.135: v2(138.11,57.6) 138.11,57.84 138.24,57.97 138.48,57.97 138.85,58.34 139.38,58.34 140.27,59.23 140.6,59.23 143.03,61.65 143.2,61.65 143.64,62.09 143.64,62.7 142.38,63.95 140.9,63.95 140.25,64.6 140.25,65.3 140.26,65.3 140.26,65.63 140.25,65.63 140.25,66.25 139.62,66.89 139.62,76.06 139.99,76.43 139.99,78.33 140.75,79.08 140.75,79.93 140.75,86.51 140.06,87.2 139.94,87.32 139.94,92.65 137.77,94.83 137.77,95.47 137.63,95.6 137.31,95.6 v2(137.11,95.41)
  BOTTOM w0.076: v2(138.11,57.6) 138.19,57.6 138.42,57.36 138.42,57.25 138.29,57.12 136.21,57.12 136.13,57.2 136.13,57.28 136.2,57.34 136.2,57.42 136.28,57.51 136.48,57.51 UC1.BW1
USB20_N1: length 147.7
  TOP w0.112: RU1.1 26.78,55.68 LU1.2 27.33,55.68 27.45,55.56 28.29,55.56 30.9,52.95 30.9,50.35 v2(31.09,50.16)
  IN1 w0.119: v2(31.09,50.16) 31.1,50.15 31.1,49.86 30.98,49.74 30.84,49.74 30.72,49.62 30.72,48.93 33.65,46 40.25,46 44.11,42.14 47.74,42.14 49.17,40.7 58.94,40.7 63.37,36.27 67.21,36.27 68.44,35.04 69.12,35.04 71.5,32.66 76.01,32.66 76.9,31.77 79.7,31.77 80.97,30.5 86.1,30.5 86.54,30.94 88.26,30.94 89.16,31.84 90.99,31.84 91.66,31.17 95.96,31.17 97.33,32.54 101.72,32.54 102.34,31.92 103.91,31.92 104.36,32.37 106.84,32.37 107.29,31.92 115.15,31.92 115.79,32.56 118.69,32.56 119.21,33.09 122.28,33.09 122.39,33.19 125.57,33.19 128.5,36.13 130.9,36.13 132.91,38.14 132.91,38.65 134.37,42.17 138.03,44.62 138.03,51.44 138.75,52.16 138.75,52.6 139.07,52.92 139.25,52.92 139.38,53.05 139.39,53.05 v2(139.54,53.21)
  BOTTOM w0.076: UC1.CE3 135.25,53.8 135.37,53.68 135.46,53.67 135.68,53.67 135.83,53.6 135.95,53.6 136.08,53.65 136.38,53.65 136.48,53.62 137.46,53.62 138.28,52.79 138.51,52.79 138.59,52.87 138.59,53.07 138.67,53.14 138.83,53.14 138.9,53.07 138.9,52.87 138.98,52.79 139.13,52.79 v2(139.54,53.21)
USB20_N1_R: length 13.2
  TOP w0.112: 19.12,55.6 19.12,55.08 19.23,54.97 19.64,54.97 20.74,56.07 23.21,56.07 23.22,56.08 24.02,56.08 24.56,55.54 24.93,55.54 25.06,55.68 LU1.1 25.61,55.68 RU1.2 ; 19.12,55.6 EU2.2 ; 19.12,55.6 18.5,54.97 18.12,54.97 v4(17.2,54.05) 16.41,53.26 15.99,53.26 15.88,53.37 JUSB1.2
USB20_N2: length 136.9
  IN1 w0.119: v2(140.61,53.32) 140.18,52.9 140.18,52.36 138.89,51.08 138.89,44.16 135.07,41.6 133.77,38.48 133.77,38.31 133.77,37.78 133.51,37.52 133.51,36.25 132.75,35.49 131.48,35.49 131.14,35.15 128.76,35.15 125.95,32.33 122.75,32.33 122.64,32.22 120.39,32.22 119.87,31.7 116.15,31.7 115.5,31.05 105.83,31.05 105.31,30.54 103.66,30.54 103.14,31.05 101.75,31.05 101.25,31.55 97.57,31.55 96.32,30.31 89.26,30.31 89.02,30.08 86.9,30.08 86.46,29.64 77.26,29.64 75.85,31.05 71.73,31.05 68.6,34.18 68.09,34.18 66.86,35.41 63.01,35.41 59.02,39.4 54.41,39.4 53.87,38.86 48.98,38.86 47.14,40.7 35.98,40.7 35.35,40.07 34.45,40.07 34.11,40.42 34.11,40.68 33.9,40.89 v2(33.9,40.89)
  BOTTOM w0.076: UC1.CE1 136.61,53.81 136.73,53.81 136.81,53.89 136.81,53.95 136.88,54.02 137.16,54.02 137.24,53.93 137.24,53.86 137.32,53.78 137.47,53.78 137.52,53.83 137.52,53.97 137.58,54.02 137.89,54.02 138.18,53.72 138.45,53.72 138.46,53.71
  BOTTOM w0.112: RU8.1 32.15,40.15 32.26,40.04 LU4.3 32.63,40.04 32.77,39.9 33.66,39.9 34.13,40.38 34.13,40.67 v2(33.9,40.89) ; 138.46,53.71 138.59,53.58 139.7,53.58 139.76,53.53 139.76,53.53 139.92,53.37 140.56,53.37 v2(140.61,53.32)
USB20_N2_R: length 24.9
  BOTTOM w0.112: JUSB2.2 15.88,29.55 16.07,29.36 16.59,29.36 16.7,29.47 16.7,32.68 19.23,35.2 21.53,35.2 22.66,36.33 22.66,37.24 v4(24.13,38.71) 25.06,39.64 26.01,39.64 26.2,39.83 26.2,40.41 26.31,40.52 EU4.3 26.91,39.83 26.96,39.78 26.96,39.78 27.07,39.67 27.56,39.67 28.36,40.47 29.79,40.47 30.36,39.9 30.61,39.9 30.75,40.04 LU4.4 31.1,40.04 RU8.2
USB20_N3: length 93.8
  TOP w0.112: v2(208.97,38.56) 208.69,38.29 208.37,38.29 208.06,37.98 208.06,37.38 LU8.2 207.94,37.22 RU16.1
  IN3 w0.135: v2(148.7,49.96) 148.82,49.84 149.26,49.84 149.56,49.54 149.56,48.76 149.29,48.49 148.39,48.49 148.14,48.24 148.14,43.15 148.7,42.59 149.61,42.59 150.63,41.58 160.19,41.58 161.04,40.73 172.38,40.73 173.1,40.01 173.1,38.99 173.81,38.29 177.33,38.29 179.39,36.22 194.76,36.22 196.96,38.42 198.52,38.42 200.36,40.27 201.4,40.27 202.05,40.92 202.64,40.92 203.26,40.31 205.75,40.31 207.66,38.4 208.81,38.4 v2(208.97,38.56)
  BOTTOM w0.076: 137.97,52.21 137.35,52.21 137.19,52.36 137.19,52.57 136.77,52.99 136.43,52.99 136.33,52.96 136.11,52.96 136.02,52.99 135.78,52.99 135.6,52.92 135.51,52.83 134.98,52.83 134.91,52.75 134.91,52.64 134.98,52.56 UC1.CG3
  BOTTOM w0.112: 137.97,52.21 138.74,52.21 138.74,52.2 138.79,52.2 138.81,52.22 142.54,52.22 142.88,51.87 145.76,51.87 147.68,49.96 v2(148.7,49.96)
USB20_N3_R: length 6.4
  TOP w0.112: RU16.2 207.94,36.05 LU8.1 207.94,35.64 208.08,35.5 208.08,35.1 208.06,35.09 208.06,34.55 208.08,34.54 208.08,33.74 v2(207.92,33.58)
  BOTTOM w0.112: v2(207.92,33.58) 208.09,33.75 208.09,34.87 207.59,35.37 207.59,35.75 207.2,36.14 JIOB1.7
USB20_N4: length 13.9
  TOP w0.112: v2(141.4,53.82) 141.57,53.65 142.2,53.65 v4(143.07,52.79) 143.75,52.11 144.09,52.11 R59.1
  BOTTOM w0.076: UC1.CD3 135.52,54.49 135.52,54.64 135.6,54.72 135.82,54.72 135.9,54.64 135.9,54.39 135.95,54.34 136.04,54.34 136.27,54.57 138.04,54.57 138.31,54.3 138.56,54.3 140.55,54.3 140.82,54.03 140.82,53.84 141.1,53.56 141.26,53.56 141.4,53.7 v2(141.4,53.82)
  BOTTOM w0.112: R57.1 143.59,52.89 143.04,52.89 142.23,53.69 141.53,53.69 v2(141.4,53.82)
USB20_N4_R: length 23.8
  TOP w0.102: v2(6.54,121.61) 6.51,121.57 JUSBC1.B7
  TOP w0.112: RT21.2 16.97,119.32 LT1.4 16.43,119.32 16.26,119.48 16.12,119.48 14.24,121.36 13.99,121.36 13.88,121.25 13.88,120.66 13.72,120.51 EU10.3 13.71,120.52 13.5,120.73 13.5,120.96 13.31,121.15 13.06,121.15 12.95,121.05 12.74,121.05 v2(12.56,120.87) 12.37,121.05 11.02,121.05 11.01,121.03 10.47,121.03 10.46,121.05 9.71,121.05 9.62,120.96 8.08,120.96 7.94,120.82 JUSBC1.A7
  IN1 w0.119: v2(12.56,120.87) 13.25,120.87 13.5,121.11 13.5,122.8 13.08,123.22 8.23,123.22 7.53,122.52 7.53,121.78 7.36,121.61 v2(6.54,121.61)
USB20_N4_RR: length 189.6
  TOP w0.112: v2(19.36,119.34) 19.23,119.47 18.64,119.47 18.48,119.32 LT1.3 18.15,119.32 RT21.1
  IN1 w0.119: v2(90.85,113.49) 90.85,113.21 90.97,113.09 91.09,113.09 91.22,112.96 91.22,112.8 91.47,112.55 92.15,112.55 94.88,109.81 105.38,109.81 107.79,107.4 117.72,107.4 129.56,95.57 131.42,95.57 133.24,93.76 136.85,93.76 138.37,92.24 138.37,70.71 140.78,68.29 145.88,68.29 151.2,62.98 151.2,53.84 151.08,53.72 150.89,53.72 150.69,53.92 150.69,53.92 v2(150.52,54.09)
  IN3 w0.135: v2(19.36,119.34) 19.52,119.5 19.54,119.5 19.72,119.68 20.72,119.68 22.96,121.92 33.56,121.92 38.27,117.21 54.63,117.21 55.56,116.28 67.22,116.28 67.81,115.69 71.96,115.69 72.29,116.02 74.28,116.02 74.54,115.76 74.55,115.76 74.61,115.69 77.23,115.69 78.31,114.61 81.48,114.61 82,114.09 91.08,114.09 91.2,113.97 91.2,113.85 91.02,113.67 91.02,113.65 v2(90.85,113.49)
  BOTTOM w0.112: R57.2 145.02,52.88 146.08,52.88 146.17,52.97 147.47,52.97 147.84,52.6 148.91,52.6 149.17,52.86 149.17,53.11 149.78,53.73 150.16,53.73 150.52,54.09 v2(150.52,54.09)
USB20_N5: length 112.4
  IN3 w0.135: v2(218.91,35.62) 218.74,35.62 218.6,35.48 218.6,35.29 218.74,35.16 219.11,35.16 219.25,35.02 219.25,34.7 218.89,34.35 216.47,34.35 216.04,33.92 210.93,33.92 210.04,34.81 207.62,34.81 206.97,34.16 206.97,33.34 206.79,33.16 202.22,33.16 200.59,34.79 199.06,34.79 197.78,33.52 189.04,33.52 188.3,32.78 178.79,32.78 176.81,30.8 176.81,30.44 175.95,29.58 172.77,29.58 170.77,31.58 169.62,31.58 167.59,33.61 163.87,33.61 163.42,34.07 149.34,34.07 148.5,34.91 148.5,35.45 143.31,40.64 143.31,41.52 140.45,44.39 140.45,47.27 138.28,49.44 137.3,49.44 134.95,51.79 134.09,51.79 133.96,51.93 133.96,52.13 134.09,52.26 v2(134.16,52.26)
  BOTTOM w0.102: v2(134.16,52.26) 133.85,52.58 UC1.CG5
  BOTTOM w0.112: JFP1.6 218.52,31.57 218.66,31.71 v4(218.66,32.06) 218.66,32.41 219.29,33.04 219.55,33.04 219.56,33.05 220.16,33.05 220.18,33.04 220.29,33.04 220.51,33.25 220.51,33.4 EU5.3 220.31,33.78 220.52,33.99 220.52,34.14 220.03,34.64 219.4,34.64 219.16,34.88 219.16,35.37 v2(218.91,35.62)
USB20_N6: length 112.3
  TOP w0.112: v2(214.36,42.48) 214.41,42.42 214.41,41.75 214.67,41.49 219.54,41.49 220.13,42.08 220.13,43.11 219.88,43.35 218.98,43.35 L3.4 218.81,43.49 R12.2
  IN3 w0.135: v2(214.36,42.48) 214.36,41.71 213.1,40.46 212.67,40.46 211.45,39.23 211.45,37.87 210.82,37.25 206.31,37.25 205.9,37.65 205.9,39.05 205.36,39.59 200.65,39.59 198.8,37.74 197.24,37.74 195.04,35.54 179.06,35.54 177.07,37.52 173.61,37.52 172.42,38.71 172.42,39.37 171.78,40.01 171.62,40.01 171.42,40.01 171.06,40.01 160.7,40.01 159.9,40.81 148.91,40.81 147.46,42.27 147.46,49.55 149.39,51.48 149.39,53.14 149,53.53 148.82,53.53 v2(148.69,53.66)
  BOTTOM w0.076: UC1.CC1 136.6,54.89 136.85,54.89 136.92,54.96 137.22,54.96 137.29,54.89 137.67,54.89 137.74,54.96 138.11,54.96 138.17,54.89 138.36,54.89 138.41,54.85
  BOTTOM w0.112: 138.41,54.85 138.54,54.72 142.4,54.72 142.75,54.38 146.05,54.38 146.82,53.61 147.74,53.61 148.05,53.3 148.32,53.3 148.43,53.41 148.43,53.55 148.55,53.66 v2(148.69,53.66)
USB20_N6_R: length 7
  TOP w0.112: R12.1 217.73,43.62 L3.3 217.17,43.49 217.05,43.37 216.34,43.37 216.06,43.64 216.06,44.23 215.81,44.49 215.45,44.49 215.23,44.7 ED3.2 214.81,44.46 214.38,44.46 v2(214.2,44.64)
  BOTTOM w0.112: JEDP1.33 212.81,44.45 212.95,44.31 213.86,44.31 v2(214.2,44.64)
USB20_N7: length 96.3
  TOP w0.112: v2(210.29,32.44) 210.44,32.59 210.44,32.95 210.27,33.12 LU7.3 210.27,33.48 RU14.1
  IN3 w0.135: v2(132.17,52.32) 131.93,52.09 131.93,51.79 132.61,51.11 134.67,51.11 137.02,48.76 138,48.76 139.77,46.99 139.77,44.1 142.63,41.24 142.63,40.35 145.44,37.55 145.44,36.82 148.87,33.39 163.13,33.39 163.59,32.93 164.8,32.93 165.62,32.11 165.62,31.15 165.95,30.81 170.57,30.81 172.49,28.89 176.31,28.89 177.49,30.08 177.49,30.48 179.11,32.1 209.71,32.1 209.85,32.24 209.85,32.82 209.97,32.93 210.24,32.93 210.37,32.79 210.37,32.51 v2(210.29,32.44)
  BOTTOM w0.102: UC1.CG8 131.9,52.59 v2(132.17,52.32)
USB20_N7_R: length 5.3
  TOP w0.112: v2(210.44,38.04) 210.63,37.85 210.63,37.54 210.41,37.32 210.41,36.58 210.4,36.57 210.4,36.04 210.41,36.03 210.41,35.34 210.27,35.2 LU7.4 210.27,34.66 RU14.2
  BOTTOM w0.112: v2(210.44,38.04) 210.61,37.88 210.61,37.61 210.2,37.2 JIOB1.4
USB20_N8: length 14.4
  TOP w0.089: 135.13,55.81 134.96,55.65 134.94,55.65 134.9,55.61 134.88,55.61 134.69,55.42 133.56,55.42 133.54,55.44 132.8,55.44 132.77,55.41 132.67,55.3 132.67,54.9 132.44,54.67 132.29,54.67 132.18,54.78 v2(132.18,55.07)
  TOP w0.112: R61.1 144.1,56.57 143.67,56.57 143.2,56.1 140.75,56.1 140.5,56.35 v4(136.18,56.35) 135.66,56.35 135.13,55.81
  BOTTOM w0.102: UC1.CB8 131.9,55.39 132.18,55.11 v2(132.18,55.07)
USB20_N8_R: length 8.8
  TOP w0.112: R84.2 207.57,40.98 207.89,40.98 207.89,40.99 207.9,40.99 v2(208.03,41.12)
  BOTTOM w0.112: L4.3 206.41,40.44 206.55,40.3 206.79,40.3 207.44,40.95 207.86,40.95 v2(208.03,41.12) 208.21,40.94 208.46,40.94 208.85,41.33 ED2.3 209.14,41.15 209.33,40.95 209.61,40.95 210.08,41.41 v4(211.07,42.41) 211.38,42.72 211.75,42.72 211.98,42.95 JEDP1.36
USB20_N8_RR: length 85.6
  TOP w0.112: R61.2 145.57,56.62 145.6,56.62 145.84,56.86 146.31,56.86 147.64,55.52 147.64,52.25 147.53,52.14 147.41,52.14 v2(147.21,52.34) 145.31,52.34 R59.2
  IN3 w0.135: v2(203.41,38.92) 203.39,38.9 203.39,38.6 203.52,38.46 203.64,38.46 203.75,38.35 203.75,38.15 202.66,37.06 197.53,37.06 195.32,34.86 178.72,34.86 176.82,36.76 173.39,36.76 171.74,38.41 171.74,38.93 171.34,39.33 153.25,39.33 152.53,40.05 148.71,40.05 146.78,41.99 146.78,49.83 148.01,51.07 148.01,51.72 147.74,52 147.57,52 147.39,52.18 147.37,52.18 v2(147.21,52.34)
  BOTTOM w0.112: R19.2 205.03,40.57 L4.4 204.72,40.44 204.57,40.29 204.16,40.29 203.78,39.91 203.78,39.28 v2(203.41,38.92)
USB20_N10: length 127
  IN1 w0.119: v2(80.42,117.09) 80.19,116.86 80.19,116.5 80.71,115.97 86.43,115.97 88.28,114.12 92.25,114.12 95.7,110.68 105.74,110.68 107.77,108.65 117.7,108.65 119.89,106.46 120.97,106.46 129.58,97.85 130.78,97.85 133.83,94.8 137.51,94.8 138.11,95.4 138.43,95.4 v2(138.59,95.56)
  IN3 w0.135: v2(140.44,57.59) 140.44,58.09 140.58,58.22 141,58.22 143.29,60.51 143.42,60.51 144.56,61.65 144.56,63.94 140.54,67.96 140.54,75.68 140.92,76.05 140.92,77.95 141.67,78.7 141.67,86.9 140.87,87.7 140.87,93.67 139.2,95.34 138.82,95.34 v2(138.59,95.56)
  BOTTOM w0.076: 138.37,55.2 138.34,55.2 138.27,55.13 136.91,55.13 136.81,55.18 136.76,55.21 136.61,55.27 136.46,55.27 136.36,55.23 136.08,55.23 135.99,55.27 135.8,55.27 135.65,55.21 135.58,55.13 135.58,54.93 135.45,54.8 135.32,54.8 135.25,54.88 UC1.CC3
  BOTTOM w0.112: v2(80.42,117.09) 80.42,118.97 80.8,119.35 80.8,121.15 80.3,121.65 JWLAN1.5 ; v2(140.44,57.59) 140.23,57.38 140.23,56.58 140.71,56.11 140.71,55.44 140.19,54.92 139.32,54.92 139.04,55.2 138.37,55.2
USB20_P1: length 147.4
  TOP w0.112: RU2.1 26.78,55.18 LU1.3 27.33,55.18 27.48,55.34 28.2,55.34 30.67,52.86 30.67,50.33 v2(30.5,50.16)
  IN1 w0.119: v2(139.54,52.63) 139.47,52.7 139.17,52.7 138.97,52.51 138.97,52.07 138.25,51.35 138.25,44.5 134.55,42.03 133.13,38.61 133.13,38.05 130.99,35.91 128.59,35.91 125.66,32.97 122.48,32.97 122.37,32.87 119.31,32.87 118.78,32.34 115.88,32.34 115.24,31.7 107.2,31.7 106.75,32.15 104.45,32.15 104,31.7 102.25,31.7 101.63,32.32 97.42,32.32 96.05,30.95 91.57,30.95 90.9,31.62 89.25,31.62 88.35,30.72 86.63,30.72 86.19,30.28 80.88,30.28 79.61,31.55 76.81,31.55 75.92,32.44 71.41,32.44 69.03,34.82 68.35,34.82 67.12,36.05 63.28,36.05 58.85,40.48 49.08,40.48 47.65,41.92 44.02,41.92 40.16,45.78 33.56,45.78 30.5,48.84 v2(30.5,50.16)
  BOTTOM w0.076: v2(139.54,52.63) 138.22,52.63 137.39,53.45 136.46,53.45 136.36,53.49 136.11,53.49 135.97,53.44 135.8,53.44 135.65,53.5 135.5,53.5 135.48,53.5 135.25,53.53 134.74,53.9 UC1.CE4
USB20_P1_R: length 13.2
  TOP w0.112: 19.12,54.12 18.5,54.75 18.21,54.75 17.55,54.09 17.55,54.08 17.18,53.7 17.16,53.7 16.5,53.04 15.99,53.04 15.88,52.93 JUSB1.3 ; 19.12,54.12 EU2.3 ; 19.12,54.12 19.12,54.64 19.23,54.75 19.73,54.75 20.83,55.84 v4(23.49,55.84) 23.95,55.84 24.47,55.32 24.93,55.32 25.06,55.18 LU1.4 25.61,55.18 RU2.2
USB20_P2: length 136.9
  IN1 w0.119: v2(140.24,53.78) 140.22,53.76 140.22,53.52 140.19,53.5 140.19,53.22 139.96,52.99 139.96,52.45 138.67,51.17 138.67,44.28 134.89,41.75 133.55,38.52 133.55,38.22 133.55,37.87 133.29,37.61 133.29,36.34 132.66,35.71 131.39,35.71 131.05,35.36 128.67,35.36 125.86,32.55 122.66,32.55 122.55,32.44 120.3,32.44 119.78,31.92 116.06,31.92 115.41,31.27 105.73,31.27 105.22,30.76 103.75,30.76 103.23,31.27 101.84,31.27 101.34,31.77 97.48,31.77 96.23,30.53 89.16,30.53 88.93,30.3 86.81,30.3 86.37,29.86 77.35,29.86 75.94,31.27 71.82,31.27 68.69,34.4 68.18,34.4 66.95,35.63 63.11,35.63 59.11,39.62 54.32,39.62 53.78,39.08 49.07,39.08 47.23,40.92 35.88,40.92 35.26,40.29 34.54,40.29 34.33,40.51 34.33,40.73 v2(34.49,40.89)
  BOTTOM w0.076: 138.61,53.85 138.6,53.86 138.57,53.86 138.54,53.89 138.44,53.89 138.44,53.89 138.25,53.89 137.96,54.18 136.47,54.18 UC1.CE2
  BOTTOM w0.112: 138.61,53.85 138.67,53.78 139.78,53.78 139.84,53.73 139.85,53.73 140,53.57 140.16,53.57 140.24,53.65 v2(140.24,53.78) ; v2(34.49,40.89) 34.35,40.75 34.35,40.28 33.75,39.68 32.71,39.68 32.57,39.54 LU4.2 32.28,39.54 RU7.1
USB20_P2_R: length 24.9
  BOTTOM w0.112: RU7.2 31.1,39.54 LU4.1 30.78,39.54 30.64,39.68 30.27,39.68 29.7,40.25 28.45,40.25 27.65,39.45 27.07,39.45 26.91,39.28 EU4.2 26.37,38.59 26.26,38.7 26.26,39.24 26.08,39.42 25.15,39.42 24.52,38.78 24.52,38.77 24.08,38.32 24.06,38.32 22.89,37.16 v4(22.89,36.71) 22.89,36.25 21.62,34.98 19.32,34.98 16.93,32.59 16.93,29.38 16.68,29.14 15.99,29.14 15.88,29.03 JUSB2.3
USB20_P3: length 93.7
  TOP w0.112: v2(208.97,37.98) 208.88,38.06 208.46,38.06 208.31,37.92 208.31,37.38 LU8.3 208.44,37.22 RU15.1
  IN3 w0.135: v2(148.7,49.37) 148.93,49.6 149.16,49.6 149.32,49.44 149.32,48.86 149.19,48.73 148.29,48.73 147.9,48.34 147.9,43.05 148.6,42.35 149.51,42.35 150.53,41.33 160.09,41.33 160.94,40.49 172.28,40.49 172.86,39.91 172.86,38.89 173.71,38.04 177.23,38.04 179.29,35.98 194.86,35.98 197.06,38.18 198.62,38.18 200.46,40.02 201.5,40.02 202.15,40.68 202.54,40.68 203.16,40.06 205.65,40.06 207.56,38.16 208.79,38.16 v2(208.97,37.98)
  BOTTOM w0.076: 137.97,52 137.96,52 137.94,52.02 137.9,52.02 137.88,52.04 137.28,52.04 137.03,52.29 137.03,52.5 136.7,52.83 136.46,52.83 136.36,52.79 136.08,52.79 135.99,52.83 135.81,52.83 135.69,52.78 135.56,52.64 135.53,52.45 135.42,52.32 135.35,52.3 135.14,52.31 134.98,52.35 UC1.CG4
  BOTTOM w0.112: 137.97,52 138.65,52 138.65,52 142.44,52 142.79,51.65 145.67,51.65 147.59,49.74 148.13,49.74 148.24,49.63 148.24,49.49 148.35,49.37 v2(148.7,49.37)
USB20_P3_R: length 6.5
  TOP w0.112: v2(208.5,33.58) 208.3,33.79 v4(208.3,34.82) 208.3,35.5 208.44,35.64 LU8.4 208.44,36.05 RU15.2
  BOTTOM w0.112: v2(208.5,33.58) 208.31,33.78 208.31,34.96 207.81,35.46 207.81,35.78 208.2,36.17 JIOB1.6
USB20_P4: length 14.1
  TOP w0.112: R60.1 144.09,51.89 143.65,51.89 143.11,52.44 143.09,52.44 142.71,52.82 142.71,52.83 142.11,53.43 141.6,53.43 v2(141.4,53.24)
  BOTTOM w0.076: UC1.CD4 135.19,54.18 136.11,54.18 136.34,54.4 137.97,54.4 138.24,54.13 138.56,54.13 140.48,54.13 140.66,53.96 140.66,53.77 141.03,53.4 141.24,53.4 v2(141.4,53.24)
  BOTTOM w0.112: v2(141.4,53.24) 141.64,53.47 142.14,53.47 142.94,52.67 143.56,52.67 R58.1
USB20_P4_R: length 23.8
  TOP w0.112: v2(6.53,121.03) 6.48,121.07 JUSBC1.B6 ; JUSBC1.A6 7.94,121.32 8.08,121.19 9.53,121.19 9.62,121.27 v4(10.74,121.27) 12.37,121.27 v2(12.56,121.45) 12.74,121.27 12.86,121.27 12.97,121.37 13.18,121.37 13.5,121.69 13.5,122.21 13.71,122.42 EU10.2 13.72,122.44 13.88,122.28 13.88,121.69 13.99,121.58 14.33,121.58 16.21,119.7 16.31,119.7 16.43,119.82 LT1.1 16.97,119.82 RT22.2
  IN1 w0.119: v2(6.53,121.03) 6.77,121.03 6.89,121.15 6.89,121.22 7.07,121.39 7.45,121.39 7.75,121.69 7.75,122.43 8.32,123 12.99,123 13.28,122.71 13.28,121.2 13.16,121.08 12.93,121.08 12.73,121.28 12.72,121.28 v2(12.56,121.45)
USB20_P4_RR: length 189.6
  TOP w0.112: v2(19.36,119.92) 19.13,119.69 18.64,119.69 18.52,119.82 LT1.2 18.15,119.82 RT22.1
  IN1 w0.119: v2(150.52,53.5) 151.17,53.5 151.41,53.75 151.41,63.07 145.97,68.51 140.87,68.51 138.59,70.8 138.59,92.33 136.94,93.98 133.33,93.98 131.51,95.79 129.65,95.79 117.81,107.62 107.88,107.62 105.47,110.03 94.97,110.03 92.24,112.77 91.56,112.77 91.44,112.89 v2(91.44,113.49)
  IN3 w0.135: v2(91.44,113.49) 91.44,114.07 91.18,114.33 82.1,114.33 81.58,114.85 78.41,114.85 77.33,115.93 74.71,115.93 74.38,116.26 72.19,116.26 71.86,115.93 67.91,115.93 67.32,116.52 55.66,116.52 54.73,117.45 38.37,117.45 33.66,122.16 22.86,122.16 20.62,119.92 v2(19.36,119.92)
  BOTTOM w0.112: R58.2 145.04,52.66 146.17,52.66 146.26,52.75 147.38,52.75 147.75,52.38 149,52.38 149.39,52.76 149.39,53.02 149.87,53.5 v2(150.52,53.5)
USB20_P5: length 112.4
  IN3 w0.135: v2(133.55,52.26) 133.71,52.1 133.71,51.83 133.99,51.55 134.85,51.55 137.2,49.2 138.18,49.2 140.21,47.17 140.21,44.29 143.07,41.42 143.07,40.54 148.26,35.35 148.26,34.81 149.24,33.83 163.32,33.83 163.77,33.37 167.49,33.37 169.52,31.34 170.67,31.34 172.67,29.33 176.05,29.33 177.06,30.34 177.06,30.7 178.89,32.54 188.4,32.54 189.14,33.28 197.88,33.28 199.16,34.55 200.49,34.55 202.12,32.92 206.89,32.92 207.21,33.24 207.21,34.06 207.72,34.56 209.94,34.56 210.83,33.68 216.14,33.68 216.57,34.11 218.99,34.11 219.49,34.6 v2(219.49,35.62)
  BOTTOM w0.102: v2(133.55,52.26) 133.55,52.4 UC1.CG6
  BOTTOM w0.112: JFP1.5 219.02,31.57 218.89,31.7 218.89,32.33 219.38,32.82 v4(219.86,32.82) 220.38,32.82 220.73,33.16 220.73,33.37 EU5.2 220.94,33.78 220.75,33.97 220.75,34.24 220.13,34.86 219.49,34.86 219.38,34.97 219.38,35.51 v2(219.49,35.62)
USB20_P6: length 112.2
  TOP w0.112: R10.2 218.71,42.86 L3.1 218.98,43.13 219.79,43.13 219.9,43.02 219.9,42.17 219.44,41.71 214.76,41.71 214.63,41.84 214.63,42 214.72,42.1 214.88,42.1 215,42.21 215,42.42 v2(214.94,42.48)
  IN3 w0.135: v2(148.69,53.08) 148.8,53.2 148.99,53.2 149.14,53.04 149.14,51.58 147.22,49.65 147.22,42.17 148.81,40.57 159.8,40.57 160.6,39.77 171.16,39.77 171.68,39.77 172.18,39.27 172.18,39.17 172.18,39.17 172.18,39.11 172.18,39.11 172.18,38.61 173.51,37.28 176.97,37.28 178.96,35.3 195.14,35.3 197.34,37.5 198.9,37.5 200.75,39.34 205.26,39.34 205.66,38.95 205.66,37.55 206.21,37.01 210.92,37.01 211.69,37.77 211.69,39.13 212.77,40.22 213.2,40.22 214.6,41.61 214.6,41.9 214.94,42.24 v2(214.94,42.48)
  BOTTOM w0.076: UC1.CC2 136.48,54.73 138.25,54.73 138.26,54.71
  BOTTOM w0.112: v2(148.69,53.08) 147.95,53.08 147.65,53.39 146.73,53.39 145.96,54.16 142.66,54.16 142.29,54.52 138.45,54.52 138.26,54.71
USB20_P6_R: length 6.9
  TOP w0.112: v2(214.2,44.06) 214.38,44.24 214.87,44.24 ED3.3 215.23,44.11 215.39,44.27 215.72,44.27 215.84,44.14 215.84,43.55 216.24,43.14 217.09,43.14 217.25,42.99 L3.2 217.63,42.99 R10.1
  BOTTOM w0.112: JEDP1.34 212.81,43.95 212.95,44.08 214.17,44.08 v2(214.2,44.06)
USB20_P7: length 96.3
  TOP w0.112: RU13.1 210.77,33.48 LU7.2 210.77,33.09 210.66,32.98 210.66,32.64 v2(210.88,32.44)
  IN3 w0.135: v2(210.88,32.44) 210.88,32.41 210.49,32.01 209.97,32.01 209.81,31.86 179.21,31.86 177.74,30.38 177.74,29.98 176.41,28.65 172.39,28.65 170.47,30.57 165.85,30.57 165.37,31.05 165.37,32.01 164.7,32.69 163.49,32.69 163.03,33.14 148.77,33.14 145.2,36.72 145.2,37.45 142.39,40.25 142.39,41.14 139.53,44 139.53,46.89 137.9,48.52 136.92,48.52 134.57,50.87 132.51,50.87 131.69,51.69 131.69,52.16 v2(131.56,52.29)
  BOTTOM w0.102: v2(131.56,52.29) 131.31,52.74 UC1.CG9
USB20_P7_R: length 5.3
  TOP w0.112: v2(211.02,38.04) 210.85,37.88 210.85,37.45 210.63,37.23 v4(210.63,36.3) 210.63,35.34 210.77,35.2 LU7.1 210.77,34.66 RU13.2
  BOTTOM w0.112: v2(211.02,38.04) 210.85,37.87 210.85,37.57 211.2,37.22 JIOB1.3
USB20_P8: length 14.4
  TOP w0.089: v2(131.51,55.07) 131.91,55.48 132.57,55.48 132.73,55.63 133.62,55.63 133.64,55.61 134.62,55.61 134.82,55.81
  TOP w0.112: 134.82,55.81 135.57,56.57 135.9,56.57 135.91,56.58 136.44,56.58 136.46,56.57 140.59,56.57 140.84,56.32 143.1,56.32 143.58,56.79 144.07,56.79 R62.1
  BOTTOM w0.102: v2(131.51,55.07) 131.51,55.07 UC1.CB9
USB20_P8_R: length 8.8
  TOP w0.112: R85.2 207.65,40.76 207.81,40.76 v2(208.03,40.53)
  BOTTOM w0.112: L4.2 206.41,39.94 206.55,40.08 206.88,40.08 207.53,40.73 207.83,40.73 v2(208.03,40.53) 208.21,40.72 208.46,40.72 208.85,40.33 ED2.2 209.14,40.51 209.36,40.73 209.71,40.73 211.03,42.06 211.05,42.06 211.49,42.5 211.79,42.5 211.85,42.45 JEDP1.37
USB20_P8_RR: length 85.9
  TOP w0.112: R60.2 145.57,51.92 145.6,51.92 145.8,52.12 146.85,52.12 147.04,51.93 147.04,51.93 v2(147.21,51.76) 147.37,51.92 147.62,51.92 147.86,52.16 147.86,55.62 146.4,57.08 R62.2
  IN3 w0.135: v2(147.21,51.76) 147.64,51.76 147.77,51.62 147.77,51.17 146.53,49.93 146.53,41.89 148.61,39.81 152.43,39.81 153.15,39.09 171.24,39.09 171.5,38.83 171.5,38.31 173.29,36.52 176.72,36.52 178.62,34.62 195.42,34.62 197.63,36.82 202.76,36.82 204,38.05 v2(204,38.92)
  BOTTOM w0.112: R18.2 205.03,39.81 L4.1 204.6,39.94 204.48,40.07 204.25,40.07 204,39.82 v2(204,38.92)
USB20_P10: length 127
  IN1 w0.119: v2(79.83,117.09) 79.97,116.95 79.97,116.41 80.62,115.76 86.34,115.76 88.19,113.91 92.16,113.91 95.61,110.46 105.65,110.46 107.68,108.43 117.61,108.43 119.8,106.24 120.88,106.24 129.49,97.63 130.69,97.63 133.74,94.58 137.6,94.58 138.2,95.18 138.39,95.18 v2(138.59,94.98)
  IN3 w0.135: v2(139.86,57.59) 140.2,57.93 140.2,58.19 140.48,58.47 140.9,58.47 143.19,60.75 143.32,60.75 144.32,61.75 144.32,63.84 140.3,67.86 140.3,75.78 140.67,76.15 140.67,78.05 141.43,78.8 141.43,86.8 140.62,87.6 140.62,93.57 139.1,95.09 138.71,95.09 v2(138.59,94.98)
  BOTTOM w0.076: 138.31,55.4 138.2,55.29 136.95,55.29 136.89,55.32 136.84,55.36 136.64,55.43 136.43,55.43 136.33,55.4 136.11,55.4 136.02,55.43 135.76,55.43 135.56,55.34 135.47,55.26 135.05,55.26 UC1.CC4
  BOTTOM w0.112: v2(79.83,117.09) 79.83,117.43 79.94,117.54 80.09,117.54 80.2,117.64 80.2,119.06 80.58,119.44 80.58,121.06 80.21,121.43 80,121.43 79.72,121.15 JWLAN1.3 ; v2(139.86,57.59) 140.03,57.42 140.03,56.5 140.51,56.03 140.51,55.52 140.11,55.12 139.41,55.12 139.13,55.4 138.31,55.4
