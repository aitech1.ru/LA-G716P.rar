# Allegro board LA-G716P r0.1.brd (continued)
## Routing (per net, layer and track width the routed paths; a pad name or vN(x,y) marks a point on that pad's centre or on a via; arc(x,y) is an arc through that point) (continued)
+VCC_GT: length 52.7
  BOTTOM w0.102: 131.21,87.16 131.21,87.16 UC1.L10 ; UC1.N8 132.15,85.76 v2(132.15,85.55) 132.15,85.34 UC1.P8 ; UC1.N8 132.15,86.26 v2(132.15,86.47) 132.15,86.69 UC1.L8 ; UC1.N8 131.71,85.82 ; UC1.N8 131.69,86.22 ; UC1.T8 132.15,84.41 v2(132.15,84.63) 132.15,84.84 UC1.P8 ; UC1.T8 131.7,83.96 ; UC1.T8 132.15,83.92 v2(132.15,83.7) 132.15,83.49 UC1.U8 ; UC1.T8 131.69,84.37 ; 131.23,82.06 UC1.W9 ; UC1.W9 131.39,81.81 131.14,81.81 ; UC1.W9 131.49,81.81 131.74,81.81 ; UC1.W9 131.65,82.07 ; UC1.R9 131.64,84.43 131.64,84.42 ; UC1.R9 131.24,84.83 131.23,84.83 ; UC1.R9 131.64,84.83 ; UC1.R9 131.24,84.42 ; 131.69,87.14 131.69,87.14 UC1.L8 ; UC1.M9 131.26,86.29 ; UC1.M9 131.64,86.28 ; UC1.M9 131.64,86.67 ; UC1.M9 131.23,86.68 ; 131.69,84.88 UC1.P8 ; UC1.P8 131.7,85.29 ; 131.25,82.97 UC1.V9 ; UC1.V9 131.64,82.97 ; UC1.V9 131.64,82.58 ; UC1.V9 131.23,82.57 131.23,82.57 ; UC1.N10 130.78,85.81 v2(130.78,85.55) ; UC1.N10 131.18,86.21 ; UC1.N10 130.78,86.21 v2(130.78,86.47) 130.78,86.73 UC1.L10 ; UC1.N10 131.18,85.82 ; UC1.W8 132.15,82.07 v2(132.15,81.85) ; UC1.W8 131.71,82.13 131.71,82.13 ; UC1.W8 131.7,82.52 ; UC1.W8 132.15,82.56 v2(132.15,82.78) 132.15,82.99 UC1.U8 ; 131.23,85.34 UC1.N9 ; UC1.N9 131.63,85.74 ; UC1.N9 131.25,85.74 ; UC1.N9 131.63,85.36 ; UC1.U10 130.78,83.44 v2(130.78,83.7) 130.78,83.96 UC1.T10 ; UC1.U10 131.18,83.44 ; UC1.U10 131.17,83.05 ; UC1.U10 130.8,83.06 v2(130.8,82.77) ; 132.12,87.16 132.12,87.16 UC1.L8 ; UC1.L8 131.72,86.75 ; UC1.L10 131.18,86.74 ; UC1.L10 130.78,87.14 130.78,87.14 ; UC1.T10 131.18,84.36 ; UC1.T10 130.78,84.37 v2(130.78,84.63) ; UC1.T10 131.18,83.96 ; 131.71,83.43 UC1.U8 ; UC1.U8 131.69,83.03 ; 131.64,83.51 UC1.T9 ; UC1.T9 131.26,83.89 ; UC1.T9 131.64,83.9 ; UC1.T9 131.25,83.51
  BOTTOM w0.18: UC1.P2 137.24,84.95 137.76,85.47 v2(137.96,85.47) ; v2(137.66,88.32) 137.54,88.2 137.48,88.2 136.8,87.52 136.35,87.52 UC1.K2
  BOTTOM w0.203: UC1.D7 UC1.C8 UC1.B8 ; UC1.D7 v2(132.78,90.17) ; UC1.D7 UC1.C6 UC1.B6 ; UC1.B6 UC1.C7 UC1.B8 ; UC1.B6 UC1.A6 ; v2(132.78,90.17) UC1.F6 ; v2(132.78,90.17) UC1.F7 ; v2(134.08,88.32) UC1.H5 133.85,88.78 ; UC1.B8 UC1.A8 v2(132.15,93.67) ; UC1.E4 UC1.D4 UC1.C3 ; UC1.C3 UC1.B3 UC1.B4 UC1.A5 ; UC1.C3 UC1.C2 ; UC1.F7 v2(132.78,89.24) UC1.H7 v2(132.8,88.33) UC1.J7 v2(132.78,87.4) UC1.L7 v2(132.78,86.47) UC1.N7 v2(132.78,85.55) ; UC1.F7 UC1.F8 v2(132.15,89.24) UC1.H8 v2(132.17,88.33) UC1.J8 ; UC1.F5 v2(134.05,90.18) ; UC1.F5 v2(134.07,89.24) ; UC1.F5 UC1.F6 ; v2(133.44,88.33) UC1.H6 v2(133.42,89.24) UC1.F6 ; UC1.F6 v2(133.42,90.17)
  BOTTOM w0.508: RC169.1 139.86,96.96 v2(140.05,97.15)
  vias: v2(122.14,85.97) v2(122.14,85.34) v2(122.14,84.7) v2(122.14,84.01) v2(124.3,85.85) v2(125.37,92.95) v2(125.37,91.65) v2(125.37,91) v2(125.37,89.7) v2(125.37,89.05) v2(125.37,87.75) v2(125.38,85.85) v2(127.08,86.3) v2(127.26,92.95) v2(127.26,92.3) v2(127.26,91.65) v2(127.26,91) v2(127.26,89.7) v2(127.26,89.05) v2(127.26,88.4) v2(127.26,87.75) v2(128.2,92.95) v2(128.2,91.65) v2(128.2,91) v2(128.2,90.35) v2(128.2,89.7) v2(128.2,89.05) v2(128.2,87.75) v2(128.27,86.29) v2(130.13,87.7) v2(130.18,87.1) v2(130.2,86.52) v2(130.33,85.92) v2(130.35,84.16) v2(130.37,83.24) v2(130.75,81.86) v2(130.97,94.04) v2(132.74,93.66) v2(133.25,93.08) v2(148.05,103.06) v2(148.05,102.36) v2(148.05,101.72) v2(148.05,101.09) v2(149.2,98.86) v2(149.23,98.21) v2(149.23,97.58) v2(149.23,96.94) v2(149.83,98.86) v2(149.79,96.36) v2(149.79,95.72) v2(149.86,98.21) v2(149.86,97.58) v2(149.86,96.94) v2(150.37,96.36) v2(150.37,95.72) v2(150.37,95.09) v2(150.5,98.85) v2(150.5,98.21) v2(150.5,97.58) v2(150.5,96.94) v2(151,96.36) v2(151,95.72) v2(151,95.09) v2(151,94.5) v2(151.23,102.99) v2(151.23,102.36) v2(151.23,101.72) v2(151.23,101.09) v2(151.64,96.36) v2(151.64,95.72) v2(151.64,95.09) v2(151.64,94.5) v2(151.86,102.36) v2(151.86,101.72) v2(151.86,101.09) v3(146.64,89.16)
+VCC_SA: length 30.1
  TOP w0.508: 135.1,63.4 136.06,63.4 137.1,64.44 138.73,64.44 139.05,64.75 139.98,64.75 141.4,66.18 143.04,66.18 143.84,65.38 144,65.38 RC164.1
  BOTTOM w0.076: UC1.BK8 132.2,62.62 v2(132.2,62.53) 132.2,62.29 132.15,62.24
  BOTTOM w0.102: UC1.BK25 120.91,62.83 ; UC1.BK25 121.3,62.81 ; UC1.BK25 121.18,63.11 121.43,63.11 ; UC1.BK25 120.99,63.11 120.74,63.11 ; 131.19,62.2 UC1.BL10 130.75,61.76 ; UC1.BJ10 130.78,64.04 v2(130.78,64.3) 130.78,64.56 UC1.BG10 ; UC1.BJ10 131.18,63.64 ; UC1.BJ10 130.78,63.64 v2(130.78,63.38) ; UC1.BJ10 131.18,64.04 ; UC1.BL9 131.22,62.68 ; UC1.BL9 131.67,62.68 ; UC1.BL9 131.23,62.25 ; UC1.BL9 131.64,62.25 ; UC1.BG8 132.15,64.52 v2(132.15,64.3) 132.15,64.09 UC1.BJ8 ; UC1.BG8 131.77,64.89 131.59,64.89 ; UC1.BG8 131.69,64.56 ; UC1.BG8 131.97,64.84 132.25,64.84 ; 121.36,61.46 UC1.BM24 ; UC1.BM24 121.44,61.76 121.25,61.76 ; UC1.BM24 121.76,61.44 ; UC1.BL26 120.82,62.76 ; UC1.BL26 120.42,62.35 ; UC1.BL26 120.41,62.77 ; UC1.BL26 120.84,62.35 ; 131.24,64.51 UC1.BH9 ; UC1.BH9 131.64,64.5 ; UC1.BH9 131.64,64.1 ; UC1.BH9 131.24,64.1 ; 130.7,64.84 130.91,64.84 UC1.BG10 ; UC1.BK8 131.72,62.73 ; UC1.BK8 132.15,63.16 v2(132.15,63.38) 132.15,63.59 UC1.BJ8 ; UC1.BK8 131.7,63.11 ; UC1.BN25 120.87,61.41 ; UC1.BN25 121.28,61.38 ; UC1.BN25 121.33,60.95 ; UC1.BJ8 131.7,63.64 ; UC1.BJ8 131.72,64.02 ; 131.25,63.57 UC1.BJ9 ; UC1.BJ9 131.66,63.16 ; UC1.BJ9 131.23,63.17 ; UC1.BJ9 131.63,63.57 ; 120.26,62.73 120.16,62.83 UC1.BK27 120.26,63.11 120.52,63.11 ; UC1.BG10 131.11,64.89 131.34,64.89 ; UC1.BG10 131.18,64.56 ; UC1.BL8 132.15,62.24 ; UC1.BL8 131.7,62.2 ; UC1.BL8 131.8,61.89 131.54,61.89 ; 121.36,62.76 UC1.BL24 121.44,62.45 121.15,62.45
  vias: v2(121.95,62.86) v2(122.46,62.16) v2(122.59,62.8) v2(125.39,64.88) v2(125.38,62.43) v2(126.66,64.88) v2(126.65,62.43) v2(127.93,64.88) v2(127.93,62.4) v2(129.13,62.42) v2(129.2,64.88) v2(130.35,64.76) v2(152.37,56.38) v2(152.37,55.75) v2(152.37,55.11) v2(152.37,54.48) v2(153.01,55.75) v2(153.01,55.11) v2(153.01,54.48) v2(153.01,53.84) v2(153.01,53.21) v2(153.64,55.75) v3(151.81,56.07)
+VCCIO: length 28.9
  TOP w0.254: RC4.1 131.85,74.76 v2(132.15,74.46)
  TOP w0.432: CC25.1 126.96,60.61 v2(126.55,60.2)
  IN3 w0.508: v2(132.15,74.46) 132,74.61 122.41,74.61 v2(122.22,74.41)
  BOTTOM w0.102: 120.83,75.11 UC1.AK26 ; UC1.AK26 120.4,75.09 ; UC1.AK26 120.57,75.38 120.25,75.38 ; UC1.AK26 120.69,75.38 121,75.38 ; UC1.BH26 120.42,64.18 ; UC1.BH26 120.75,64.51 121,64.51 ; UC1.BH26 120.5,64.51 120.29,64.51 ; UC1.BH26 UC1.BH25 ; UC1.AM25 120.99,73.86 120.74,73.86 ; UC1.AM25 121.18,73.86 121.47,73.86 ; UC1.AM25 120.9,74.14 ; UC1.AM25 121.29,74.15 ; UC1.BJ24 121.47,63.39 121.18,63.39 ; UC1.BJ24 121.63,63.39 121.91,63.39 ; UC1.BJ24 UC1.BH25 ; 120.97,63.39 120.71,63.39 UC1.BJ26 ; UC1.AL24 121.77,74.19 v2(121.77,73.95) ; UC1.AL24 121.36,74.21 ; UC1.AL24 121.37,74.59 ; UC1.AL24 121.77,74.62 v2(121.77,74.86) 121.77,75.1 UC1.AK24 ; 120.4,74.63 UC1.AL26 ; UC1.AL26 120.83,74.61 ; UC1.AL26 120.41,74.19 ; UC1.AL26 120.82,74.21 ; 121.88,75.37 121.6,75.37 UC1.AK24 ; UC1.BJ26 120.43,63.67 ; UC1.BJ26 120.54,63.39 120.26,63.39 ; UC1.BJ26 UC1.BH25 ; v2(119.87,63.47) 119.87,63.64 UC1.BH27 ; UC1.BH24 121.43,64.51 121.2,64.51 ; UC1.BH24 UC1.BH25 ; UC1.BH24 121.6,64.43 121.86,64.43 ; 121.37,75.13 UC1.AK24 ; UC1.AK24 121.49,75.38 121.2,75.38 ; 120.89,74.66 UC1.AL25 ; UC1.AL25 121.29,75.07 ; UC1.AL25 120.88,75.07 ; UC1.AL25 121.29,74.67 ; UC1.BH27 120.36,63.73 ; UC1.BH27 119.87,64.22 v2(119.87,64.38) ; UC1.BH27 120.36,64.13
  BOTTOM w0.254: UC1.BP18 v2(126.55,60.2) UC1.BP16
  vias: v2(119.87,74.41) v2(119.87,73.5) v2(121.89,63.92) v2(122.34,64.32) v2(122.53,63.75) v2(136.39,45.36) v2(136.39,44.78) v2(136.98,45.95) v2(136.98,45.36) v2(136.98,44.78) v2(137.56,45.39) v2(137.56,44.8) v2(144.86,45.09) v2(144.86,44.51) v2(145.41,44.8) v3(144.7,42.93)
+VCCIO_OUT: length 0.8
  TOP w0.112: v3(148.43,37.3) 148.43,38.06
+VCCLDOSRAM_1P24: length 3.8
  TOP w0.127: RC133.1 v1(123.38,55.68)
  TOP w0.508: v2(122.34,56.33) 122.34,56.32 RC133.1
  BOTTOM w0.203: v2(122.34,56.33) UC1.BY23 ; v2(122.34,56.33) UC1.CA23 ; v2(122.34,56.33) UC1.CA24 ; v2(122.34,56.33) UC1.BY24
+VCCPLL_OC: length 7.2
  TOP w0.508: RZ12.2 CZ40.1 100.47,62.82 v3(102.55,62.82) 104.59,62.82 104.75,62.67
  BOTTOM w0.203: v2(119.87,62.56) 119.87,62.4 UC1.BL27 120.62,61.65 UC1.BM26
+VCCST: length 138.4
  TOP w0.508: v2(149.56,62.78) v3(148.46,62.78) 148.03,62.78 147.25,63.56 CC72.1 144.03,63.56 142.8,64.79 v2(142.8,64.8) 142.8,64.98 142.31,65.46 141.55,65.46 139.96,63.88 139.61,63.88 ; PCZ24.1 PRZ40.1 PRZ41.1 PRZ42.1 PRZ43.1 175.68,60.56 v2(175.9,60.33) ; v2(122.88,108.94) 124.49,110.55 v2(127.59,110.55)
  IN1 w0.508: 142.46,80.07 142.46,80 142.27,79.81 142.27,74.61 147.75,69.13 v2(148.49,69.13) ; 142.46,80.07 142.46,80.13 142.27,80.32 142.27,87.67 142.81,88.21 142.81,93.9 142.21,94.5 142.21,103.77 138.93,107.05 133.59,107.05 130.1,110.55 v2(127.59,110.55) ; 142.46,80.07 v2(142.91,80.07)
  IN2 w0.508: v2(174.85,64.26) 174.56,63.97 174.56,61.68 v2(175.9,60.33)
  IN3 w0.508: v2(149.56,62.78) 149.56,59.96 150.48,59.04 159.24,59.04 161.02,60.81 161.02,65.58 162.1,66.67 165.26,66.67 167.88,64.05 174.65,64.05 v2(174.85,64.26)
  BOTTOM w0.18: v2(137.13,60.53) 137.11,60.54 UC1.BP2
  BOTTOM w0.203: UC1.BR11 130.35,59.79 v2(130.88,59.54) 130.4,59.21 UC1.BT11
  BOTTOM w0.254: v2(130.87,60.6) 130.79,60.52 UC1.BP11
  BOTTOM w0.508: RC136.1 RC3.1 140.81,80.45 141.19,80.07 v2(142.91,80.07) 143.25,80.07 143.73,79.58 143.73,78.99 143.29,78.54 RC134.1 ; RC2.1 139.76,63.99 RC145.1 140.5,63.99 142.29,63.99 142.8,64.5 v2(142.8,64.8) 147.14,69.13 v2(148.49,69.13)
+VCCST_OUT:
  vias: v1(125.9,110.28)
+VCCSTG: length 88.6
  TOP w0.508: RC150.1 RC151.1 v2(145.89,83.43) 145.96,83.5 146.7,83.5 147.21,82.99 v3(147.21,82.64) 147.21,82.27 146.85,81.91 RC152.1 ; v2(121.83,104.71) 129.64,96.9 134.5,96.9 137.03,94.37 139.62,94.37 141.19,95.94 141.19,96.96 144.15,99.91 v2(144.15,100.45) ; v2(142.91,81.34) 141.13,81.34 139.29,79.5 139.29,76.06 137.84,74.61 134.58,74.61 134.45,74.48 v2(133.51,74.48)
  IN1 w0.508: v2(137.58,66.16) 137.58,66.29 136.05,67.81 136.05,73.46 135.04,74.48 v2(133.51,74.48) ; v2(145.89,83.43) 146,83.43 146.5,83.94 146.5,85.18 144.66,87.02 144.66,98.81 144.15,99.31 v2(144.15,100.45)
  BOTTOM w0.203: UC1.BG3 UC1.BG2 UC1.BG1 136.98,65.2 137.18,65.2 137.58,65.59 v2(137.58,66.16)
  BOTTOM w0.254: CC19.1 138.17,66.1 138.11,66.16 v2(137.58,66.16)
  BOTTOM w0.508: RC1.1 v2(142.91,81.34) 143.02,81.34 145.11,83.43 v2(145.89,83.43)
+VCCSTG_OUT: length 1
  BOTTOM w0.112: CZ8.1 v1(125.81,103.3)
+VDD_CT: length 5.8
  TOP w0.102: v2(119.86,136.28) 120.08,136.28 v1(120.38,136.58)
  TOP w0.508: RV7.2 v2(112.56,137.08)
  BOTTOM w0.381: v2(119.86,136.28) UV1.AB21 119.12,137.02 v2(118.56,137.02) ; v2(119.86,136.28) 120.14,136.57 120.34,136.76 UV1.AA21 ; v2(119.86,136.28) 119.38,135.8 UV1.AB20 ; v2(119.86,136.28) UV1.AA20
+VDDR3: length 19
  TOP w0.102: v1(120.46,133.61) 120.05,133.61 v2(119.85,133.41)
  BOTTOM w0.254: 115.77,134.49 115.77,134.7 115.5,134.98 112.53,134.98 112.24,135.26 111.46,135.26 ; 115.77,134.49 115.5,134.22 112.97,134.22 112.65,133.9 112.11,133.9 112.07,133.94 ; 115.77,134.49 116.14,134.49
  BOTTOM w0.381: 116.14,134.49 116.61,134.49 116.65,134.53 118.29,134.53 v2(118.4,134.64) 119.18,134.64 UV1.AB18 UV1.AA18 UV1.AA17 119.95,133.41 v2(119.85,133.41) 119.46,133.8 UV1.AB17
  BOTTOM w0.508: 112.07,133.94 111.84,133.94 111.46,134.32 111.46,135.26 110.66,135.26 RV10.2
GND: length 2739
  TOP w0.203: v2(50.07,76.64) 50.11,76.61 UE1.51 ; v2(50.03,81.64) 50.2,81.81 UE1.64 ; UE1.100 37.06,80.61 v2(38.16,81.7) ; v2(37.07,71.21) 36.87,71.01 UE1.124 ; UE1.84 v2(42.15,84.83) ; v2(44.61,70.3) 44.58,70.3 43.75,69.47 UE1.17 ; PUM01.3 v2(36.85,31.31) ; v2(37.98,31.19) 37.65,30.85 PUM01.1 ; v2(40.6,57.88) 40.45,58.03 UZ3.11 ; CC61.2 125.67,54.96 v2(125.71,55)
  TOP w0.229: PCI138.2 131.13,80.48 130.36,80.48 v2(130.34,80.5)
  TOP w0.254: v2(8.37,123.78) 8.12,123.78 8.08,123.82 8,123.82 ; v2(114.78,137.22) RV12.2 115.25,136.16 CV29.2 ; RC72.2 129.96,48.45 129.19,47.68 v2(129.05,47.68) ; v2(112.74,135.53) 112.97,135.29 113.3,135.29 113.76,134.83 RV14.2 CV30.2 ; 131.16,78.62 v2(130.35,78.62) ; 120.68,60.26 120.54,60.12 v2(120.54,59.95) ; CC55.2 125.93,57.63 v2(126.55,58.25) ; CV32.1 61.83,124.09 62.53,124.79 UV3.3 ; 126.65,129.47 v2(126.65,129.47) ; v2(130.35,79.54) 130.37,79.56 PCI137.2 ; PCI139.2 131.15,81.4 130.36,81.4 v2(130.35,81.42)
  TOP w0.279: JUSBC1.A1 7.35,123.82 8,123.82 ; v2(7.91,117.79) 7.91,118.04 7.63,118.32 JUSBC1.A12
  TOP w0.305: JVGA1.4 v2(218.71,37.25) ; v2(218.56,34.79) 218.56,34.6 218.21,34.25 JVGA1.10 ; v2(148.62,41.66) 149.12,41.17 UZ2.5 ; v2(39.21,98.17) 39.25,98.13 JDEG1.10 ; JVGA1.1 v2(218.77,38.75) ; UZ7.5 v2(98.59,60.17)
  TOP w0.356: v2(117.32,128.69) 117.45,128.82 CV33.2 CV34.2 ; v2(56.93,64.72) 56.3,65.36 RD20.2 ; CV84.2 130.2,123.59 CV85.2 ; PCI135.2 131.01,78.47 PCI136.2 PCI134.2 PCI140.2 130.5,76.93 v2(130.31,76.75) ; CC14.2 93.25,56.27 RC105.2 ; CD13.2 77.75,47.56 v2(77.72,47.52) ; v2(154.34,130.23) 154.19,130.08 CV176.2 ; C16.2 v2(222.41,58.22) ; v2(63.2,37.96) 63.38,37.78 C3.2 ; PC2504.2 73.78,116.34 74.13,115.98 v2(74.13,115.61) ; CV65.2 118.91,135.54 v2(118.65,135.8) ; CD12.2 68.17,63.05 67.92,63.3 67.92,63.71 v2(67.85,63.77) ; v2(115.59,74.08) 115.91,73.76 CC43.2 ; v2(116.41,90.95) 116.49,91.04 RC172.2 ; CD36.2 69.54,85.57 v2(69.62,85.66) ; v2(109.89,112.9) 109.89,109.65 107.11,106.87 UC2.3 ; CD39.2 57.48,86.09 57.12,85.74 v2(57.02,85.74) ; CD15.2 75.45,58.22 v2(75.36,58.14) ; CV20.2 118.22,132.94 v2(118.22,133.43) ; CD10.2 68.53,69.15 v2(68.61,69.06) ; CV174.2 150.4,116.64 150.94,117.18 v2(150.94,117.33) ; 15.36,86.67 15.36,87.02 v2(14.92,87.46) ; v2(164.88,145.09) 164.57,144.78 CV150.2 ; v2(132.51,124.66) 132.53,124.63 CV93.2 CV92.2 ; CC44.2 115.78,76.79 v2(115.59,76.6) ; v2(160.02,135.76) 159.97,135.71 CV159.2 ; v2(155.8,38.67) 154.91,38.67 154.47,39.11 CZ9.2 CZ10.2 ; CV154.2 156.21,135.73 v2(156.14,135.8) ; v2(64.95,102.07) 64.96,102.09 CD38.2 ; CC78.1 94.28,42.53 94.85,43.1 UC8.3 ; CD35.2 57.07,63.94 v2(56.9,64.11) ; CD14.2 72.33,52.73 v2(72.35,52.75) ; CC57.2 132.29,47.54 CC56.2 ; v2(65.01,47.49) 65.07,47.56 CD41.2 ; RV41.1 128.32,124.28 CV83.2 127.59,124.73 v2(127.34,124.48) ; CD40.2 65.17,74.73 v2(65.13,74.78) ; v2(65.06,58.11) 65.41,58.46 CD42.2 ; CV175.2 152.45,127.85 v2(152.31,127.71) ; v2(158.33,135.76) 158.19,135.62 CV156.2 ; CV180.2 152.02,130.18 v2(151.91,130.29) ; CV177.2 157.9,130.58 v2(157.9,130.15) ; v2(115.59,69.05) 116.03,69.49 CC41.2 ; CD37.2 69.57,91.12 v2(69.63,91.17) ; CD8.2 81.73,67.09 v2(82.08,66.74) ; v2(120.19,47.32) 120.21,47.34 CC66.2 CC65.2 ; v2(115.59,84.15) 116.43,84.99 CC42.2 ; CD26.2 67.66,83.84 v2(67.98,84.16) ; PCM13.2 35.2,24.48 v2(35.98,24.48) ; CD11.2 81.1,69.19 v2(81.22,69.06) ; CV181.2 v2(165.34,130.11) ; CZ18.2 38.99,55.97 38.36,55.97 38.26,55.88 CZ14.2 ; v2(31.78,23.76) 31.66,23.88 PCM14.2 ; CV26.2 116.09,131.61 v2(116.49,132.01) ; CD9.2 81.1,91.26 v2(81.07,91.29) ; CV179.2 v2(165.49,125.79) ; CC64.2 v2(125.26,47.3) ; CZ13.2 v2(35.21,57.84)
  TOP w0.381: v2(115.63,61.62) 115.82,61.81 RC20.2 ; C7.2 212.14,57.44 C8.2 211.66,56.83 v2(211.12,56.28) ; CU16.2 206.18,35.57 v2(206.41,35.8) ; CV163.2 164.65,137.63 v2(164.88,137.86) ; v2(76.93,124.58) 76.5,124.58 PCV27.2 76.31,124.51 75.52,125.3 PCV34.2 ; RV49.2 160.36,125.24 CV171.2 160.52,125.94 v2(160.33,126.13) ; v2(207.28,50.95) 206.87,50.54 PQB33.3 ; v2(30.72,67.01) 30.72,67.15 30.96,67.39 31.83,67.39 32.2,67.76 CE27.2 ; RC60.1 117.41,46.26 117.79,45.88 v2(117.95,45.88) ; RL9.2 23.66,87.96 CL16.2 ; CV189.2 v2(165.63,121.72) ; CV191.2 v2(165.63,119.69) ; CV167.2 v2(160.3,150.6) ; UC9.3 98.31,52.27 v2(98.51,52.07) ; v2(99.06,54.45) 98.57,54.94 UC4.3 ; RV9.2 CV28.2 117.55,134.26 118.22,133.58 v2(118.22,133.43) ; v2(118.65,135.8) 118.65,136.27 CV64.2 ; CC60.2 123.45,59.77 v2(123.24,59.56) 122.73,59.56 CC52.2 122.03,59.14 CC63.2 ; CV185.2 v2(165.64,129.02) ; CV190.2 v2(165.63,120.71) ; v2(35.21,57.84) 35.58,57.48 CZ41.2 ; RD7.2 67.62,67.03 v2(67.85,66.8) ; U2.2 212.97,38.03 C37.2 v2(213.37,39.05) ; RC56.2 125.64,42.96 125.3,42.62 124.61,42.62 v2(124.48,42.49) ; CV46.2 127.73,139.53 128.05,139.85 128.05,142.13 v2(127.86,142.32) ; CV183.2 v2(165.64,126.86) ; v2(215.93,55.56) 215.81,55.56 215.25,55 R77.1 ; v2(212.75,32.34) C35.2 212.09,33.1 R72.2 ; v2(218.35,45.21) 217.98,45.21 217.15,44.38 ED3.1 ; CV188.2 v2(165.63,122.74) ; CV168.2 v2(159.34,150.59) ; CV182.2 v2(165.64,124.7) ; CV184.2 v2(165.64,127.94) ; CV169.2 v2(157.43,150.59)
  TOP w0.406: v2(15.53,117.66) 15.53,117.64 15.48,117.64 15.21,117.91 EU9.3 ; UE2.3 38.37,89.2 38.65,89.47 v2(39.15,89.47) ; QS1.4 167.49,30.9 v2(167.19,31.21) ; JDEG1.12 38.25,99.07 v2(38.45,98.86) ; v2(44.93,101.28) 44.75,101.1 JDEG1.11 ; PQ12.1 v2(168.83,36.75) ; QT1.4 v2(22.12,116.66) ; v2(22.68,115.25) 22.77,115.25 22.88,115.36 QT1.1 ; EU8.3 v2(15.27,125.03) ; EU3.3 v2(17.43,31.81) ; UC6.3 98.6,38.84 99.12,39.36 v2(99.16,39.36)
  TOP w0.432: v2(121.5,56.29) 121.4,56.39 CC59.2 ; RC209.2 118.06,50.08 v2(117.52,50.08) ; C36.2 211.61,46.48 211.18,46.05 v2(211.18,45.9)
  TOP w0.457: PCV32.2 68.3,124.56 v2(67.81,125.04) ; v2(129.31,128.69) 128.79,128.16 CV44.2 ; v2(126.75,49.5) 126.86,49.39 RC64.2 ; CD20.2 77.37,81.59 v2(77.32,81.64) ; RC16.2 121.26,55.42 v2(121.53,55.69) ; v2(130.45,122.05) 130.45,122.44 130.2,122.69 CV84.2 ; CA31.2 v2(25.7,3.54) ; PRM11.2 32.91,32.85 v2(32.52,32.85) ; v2(17.81,58.35) 18,58.53 EU1.3 ; CA30.2 21.29,2.73 v2(21.94,2.73) CA29.2
  TOP w0.508: v2(170.34,52.31) 170.66,51.99 PHZ04.2 ; v2(129.91,54.32) 129.99,54.41 CC49.2 ; R53.2 132.19,43.57 131.65,43.03 v2(130.55,43.03) ; v2(131.44,47.56) CC57.2 ; CD25.2 70.14,65.57 v2(69.71,65.15) ; PCZ24.2 178.79,62.3 v2(178.41,62.68) ; RC13.1 130.67,51.32 130.43,51.08 v2(130.12,51.08) ; RX22.1 90.05,31.68 v2(90.6,31.13) ; CE25.2 32.2,70.97 32.7,71.48 v2(33.15,71.48) ; v2(143.48,67.88) 143.72,67.64 RC165.2 ; CE13.2 CE20.1 55.03,79.05 55.47,79.5 55.47,81.08 54.77,81.78 53.21,81.78 53.16,81.83 v2(53.04,81.83) ; CC13.2 100.36,58.48 100.57,58.27 v2(100.6,58.27) ; CV32.1 59.14,124.09 v2(58.71,124.52) 58.96,124.77 RV165.2 ; PCI120.2 157.96,70.8 v2(157.96,71.18) ; v2(115.66,51.44) 115.66,51.65 116.21,52.21 RC54.1 ; PCI116.2 127.99,68.13 v2(127.99,68.51) ; RC61.1 125.48,52.97 v2(124.94,52.97) ; PRH02.2 PCH09.2 164.03,44.37 163.67,44.73 v2(163.67,45.58) ; v2(156.63,76) 156.63,75.62 PCI119.2 ; RD13.2 70.28,62.67 v2(69.38,61.77) ; v2(64.57,70.84) 64.91,70.49 CD49.2 ; RC74.1 117.38,52.21 117.86,51.72 v2(117.86,51.68) ; PCC02.2 130.07,76.5 v2(130.31,76.75) ; v2(96.26,47.52) 95.75,47.52 94.95,48.31 CC68.2 ; v2(54.01,135.69) 54.25,135.46 PQ2.3 ; RD23.2 CD51.2 57.25,69.72 v2(56.93,70.04) ; RC139.2 147.23,81.15 v2(147.86,80.51) ; C25.2 C24.2 128.44,29.24 128.05,29.64 126.76,29.64 v2(126.56,29.44) ; v2(146.66,54.54) 146.4,54.8 RC123.2 RC125.2 ; v2(156.63,78.42) 156.63,78.04 PCI129.2 ; C9.2 211.54,55.62 v2(211.21,55.62) ; v2(221.37,48.09) 221.14,48.32 ED4.1 ; PCI103.2 154.15,70.8 v2(154.15,71.18) ; v2(92.05,43.37) 92.05,42.93 92.46,42.52 CC69.2 92.85,42.53 CC78.1 ; CZ15.2 38.25,59.89 v2(38.41,59.72) ; PCI108.2 155.42,70.8 v2(155.42,71.18) ; v2(119.34,51.63) 119.82,51.15 RC73.1 ; CE32.1 35.67,67.13 v2(35.28,67.52) ; CE2.2 37.61,65.23 v2(37.64,65.2) ; v2(182.81,56.82) 182.74,56.74 PRZ01.2 182.15,56.72 181.37,56.72 PCZ03.2 ; v2(218.73,56.72) 218.37,57.08 U1.2 ; v2(125.45,68.51) 125.45,68.13 PCI114.2 ; DA6.1 v2(18,7.91) ; v2(118.6,62.56) 118.6,62.03 118.53,61.98 RC17.2 ; v2(183.74,72.64) 184.02,72.36 C27.2 ; v2(72.18,107.19) 71.98,106.99 CD46.2 ; PCI130.2 126.59,75.37 v2(126.59,75.75) ; RE45.1 v2(37.12,88.27) ; RD24.2 57.85,64.94 57.74,64.94 57.52,64.72 v2(56.93,64.72) ; PQB31.3 198.73,46.72 PRB45.2 198.03,46.35 v2(198.28,46.1) ; v2(77.32,78.26) 77.35,78.29 CD22.2 ; EU10.1 16.8,121.47 v2(17.18,121.85) ; PCI125.2 156.69,70.8 v2(156.69,71.18) ; v2(55.72,83.88) 55.09,84.51 CE1.2 ; v2(103.6,48.13) 103.36,47.89 CC12.2 102.96,46.21 102.46,45.7 v2(102.46,44.32) 102.46,43.42 102.77,43.11 106.4,43.11 106.78,43.49 v2(106.78,45.25) 106.78,45.7 106.27,46.21 CC11.2 106.06,48.41 v2(105.89,48.57) ; PD2.2 51.74,131.11 v2(51.85,131) ; C18.2 211.61,41.76 209.93,41.76 v2(209.66,42.03) PCB14.2 ; v2(181.45,36.69) 181.45,36.52 CS31.2 ; v2(95.9,39.55) 95.9,39.73 96.74,40.57 96.74,41.17 97.11,41.54 CC67.2 96.33,41.84 96.09,41.61 95.67,41.61 95.18,41.12 Q7.3 ; RC105.2 92.36,55.94 v2(91.76,56.54) ; RD12.2 70,66.53 v2(69.72,66.8) ; CC70.2 97.11,46.11 v2(97.24,46.24) ; RC71.2 126.86,48.17 RC64.2 ; CC15.2 130.87,58.57 v2(130.84,58.6) ; CW2.2 69.13,116.19 CW1.2 67.61,116.18 v2(67.19,115.75) ; RL7.1 19.02,79.76 v2(18.87,79.92) 18.87,80.31 CL7.2 ; v2(23.88,21.62) 24.04,21.47 RA18.2 ; PD6.1 v2(167.42,41.65) ; v2(191.44,66.06) 191.78,65.72 CO1.2 192.05,65.01 191.93,64.89 CO3.2 ; v2(73.82,37.19) 73.67,37.33 73.56,37.45 CZ23.2 ; PCV10.2 69.57,131.54 v2(69.71,131.68) ; v2(126.49,86.29) 126.49,85.88 PCG110.2 ; CL17.2 29.7,78.98 29.14,79.54 CL10.2 28.04,79.54 v2(27.87,79.37) ; CX7.2 81.56,33.69 81.59,33.66 RX14.2 81.19,33.24 v2(81.19,33.02) ; CX7.2 81.56,34.46 81.54,34.49 CX5.2 ; CX7.2 CX6.2 ; v2(67.41,136.9) 67.73,137.22 CW3.2 CW4.2 ; PCG108.2 127.67,85.9 v2(127.67,86.29) ; v2(216.82,47.26) 216.48,47.26 R76.1 ; CT18.2 12.19,122.61 v2(12.61,122.2) ; v2(44.99,63.75) 44.74,64 CE17.2 ; CV27.2 v2(111.98,131.95) ; CO2.2 190.72,66.73 190.21,66.23 v2(190.21,65.97) ; v2(88.36,40.38) 88.43,40.44 CC77.1 89.06,39.57 RX21.1 ; CD19.2 72.63,78.15 v2(72.75,78.26) ; v2(223.36,29.14) 223.06,29.45 JVGA1.18 ; CI9.2 v2(14.05,102.24) ; CE16.2 RE24.2 CE30.2 v2(49.9,87.9) ; C33.2 59.77,30.25 v2(58.27,28.75) ; v2(129.95,53.66) 130.3,53.31 RC124.2 ; CZ11.2 v2(153.96,42.98) ; PD14.1 v2(183.42,43.62) ; PCI123.2 157.96,78.04 v2(157.96,78.42) ; v2(178.47,47.05) 179.04,47.62 PDB13.1 ; PCI118.2 152.88,70.8 v2(152.88,71.18) ; CE15.2 35.33,86.88 34.77,86.31 v2(34.77,85.85) ; v2(72.3,74.02) 72.25,73.97 CD23.2 ; PRV18.2 66.2,128.28 PCV20.2 PRV16.2 66.32,130.09 v2(66.58,130.36) ; RV29.1 118.33,139.77 118.49,139.93 119.09,139.93 RV59.1 119.18,140.54 v2(119.01,140.72) ; RL11.1 v2(15.19,88.67) ; v2(42.01,91.75) 42.01,91.31 41.89,91.19 CE22.2 CE24.2 ; PCZ33.2 v2(173.47,64.64) ; CD17.2 69.5,96.71 v2(69.46,96.75) ; C6.2 215.55,60.57 v2(215.87,60.26) ; CE17.2 CE23.2 ; CE17.2 CE4.1 ; CD50.2 64.72,76.67 v2(64.6,76.8) ; PRB04.2 196.33,62.49 v2(195.93,62.1) ; v2(121.8,53.11) 121.8,53.54 RC120.2 RC205.1 ; PCV31.2 71.9,120.54 v2(71.74,120.38) ; CD47.2 57.2,105.93 v2(56.87,105.6) ; v2(20.23,53.4) 21.2,54.38 EU2.1 ; CV152.2 160.97,140.58 v2(160.31,139.93) ; RT20.1 21.88,118.49 v2(22.07,118.3) ; CE8.2 CE9.2 55.03,82.48 v2(55.72,83.18) ; v2(217.39,28.71) 216.59,29.51 C4.1 ; v2(124.18,68.51) 124.18,68.13 PCI113.2 ; R75.1 v2(217.64,51.67) ; PDM01.2 36.08,23.12 v2(35.59,22.63) ; v2(31.44,79.68) 31.8,79.68 31.94,79.81 CE7.2 ; DE1.2 36.98,85.41 v2(37.37,85.02) ; v2(56.76,96.69) 56.78,96.71 CD48.2 ; CD45.2 58.8,80.03 v2(59.85,81.08) ; 146.14,59.55 v2(146.16,59.53) ; 146.14,59.55 145.93,59.75 CC53.2 ; 146.14,59.55 146.14,60.46 145.83,60.76 CC54.2 ; CC3.2 102.64,53.14 v2(102.36,52.86) ; CU10.2 23.31,37.36 v2(22.7,37.97) 22.64,38.03 21.95,38.03 CU9.2 ; RX13.2 86.15,40.25 v2(86.29,40.39) ; R2.2 67.73,30.73 v2(67.53,30.92) ; JVGA1.17 v2(221.25,39.59) ; v2(15.92,124.82) 16.19,125.09 CT6.2 CT11.2 ; CS3.2 v2(28.75,27.74) ; v2(72.68,135.58) 73.19,135.07 PRV02.2 PRV04.2 PRV05.2 ; RV40.1 129.6,119.17 v2(128.99,118.56) ; RV43.2 v2(99.54,117.72) ; PRV27.2 76.39,122.91 v2(76.36,122.93) ; RL9.2 23.71,88.07 24.01,88.37 24.01,89.11 v2(24.37,89.47) ; CV91.2 134.1,122.17 v2(134.15,122.23) ; CE3.1 33.24,73.54 32.98,73.27 v2(32.98,73.2) ; PRV10.2 69.58,134.63 v2(69.38,134.42) ; v2(126.97,117.79) 127.35,117.79 127.99,118.42 RV19.2 ; PCW13.2 v2(148.94,112.67) ; PC3.2 v2(84.17,149.41) ; v2(121.77,50.49) 121.57,50.29 CC58.2 ; UU2.2 202.36,31.73 v2(201.14,32.95) ; v2(124.05,75.75) 124.05,75.37 PCI102.2 ; v2(82.9,129.73) PCV11.2 PCV12.2 ; QI1.3 25.1,91.88 v2(24.55,91.32) ; CE6.2 54.57,73.38 v2(55.03,73.38) ; CD43.2 57.32,53.4 v2(56.98,53.74) ; PCI126.2 157.96,75.62 v2(157.96,76) ; v2(202.76,38.92) 202.76,38.23 CU17.2 ; RC15.2 120.55,57.84 v2(120.59,57.79) ; R65.1 59.33,34.3 59.09,34.54 v2(59.09,35.11) C2.2 ; v2(72.74,28.32) 73.45,29.03 73.45,30.67 72.94,31.17 CZ20.2 ; CE18.2 RE26.2 RE40.2 CE19.2 47.53,62.78 v2(48.03,62.28) ; RE44.1 34.21,89.64 34.99,88.87 v2(35.39,88.87) ; v2(64.55,72.34) 64.7,72.19 CD16.2 ; PC4.2 v2(85.19,149.41) ; v2(76.42,110.3) 76.42,111.83 75.85,112.4 PC2503.2 ; CA11.2 27.78,9.96 v2(27.4,9.58) 26.89,9.58 CA10.1 ; DA7.1 v2(17.11,20.76) ; RX11.1 92.55,34.47 v2(91.78,35.25) ; RE57.2 v2(39.72,93.01) ; PCM16.2 32.32,30.06 32.08,29.82 v2(32.08,29.54) 32.48,29.13 PCM15.2 ; EC2.2 v2(224.27,64.52) ; v2(148.02,64.35) 147.42,64.96 CC72.2 ; v2(18.91,83.8) 19.04,83.67 CL1.2 ; PD1.1 57.88,132.33 v2(57.82,132.39) ; CS4.2 v2(28.75,25.08) ; PR43.2 v2(163.47,38.68) ; CD21.2 77.33,79.94 v2(77.32,79.95) ; RV53.2 RV135.2 v2(164.9,141.85) ; CE12.2 30.93,71.92 v2(30.48,72.37) 30.87,72.75 RE32.2 ; CD44.2 59.11,75.88 v2(60.03,76.8) ; RT19.1 v2(23.91,118.98) ; v2(16.16,2.47) 16.67,2.98 DA2.1 ; CA25.2 v2(25.69,21.65) ; R17.2 v2(222.79,56.13) ; v2(126.72,68.51) 126.72,68.13 PCI115.2 ; PR40.2 v2(169.58,36.71) ; v2(125.32,75.75) 125.32,75.37 PCI104.2 ; Q18.3 61.9,37.03 62.02,37.15 v2(62.02,38.17) ; PD3.2 v2(50.44,133.52) ; PCI101.2 129.26,68.13 v2(129.26,68.51) ; v2(23.93,98.6) 23.95,98.58 PC508.2 ; RT17.1 v2(23.66,127.19) ; C5.2 215.68,59.43 215.7,59.42 v2(216.38,59.42) ; PCB13.2 208.75,47.15 208.14,47.76 v2(208.14,48.19) ; CL2.2 19.55,87.61 UL2.2 18.77,87.61 18.43,87.28 v2(18.43,86.66) ; CD18.2 78.93,102.02 v2(77.83,102.02) ; PC303.2 19.56,43.37 v2(19.89,43.04) 19.99,42.93 PC308.2 ; v2(22.01,125.73) 21.56,126.18 RT18.1 ; v2(74.13,115.61) 74.13,115.3 73.62,114.79 PC2501.2 ; PQ11.3 163.1,35.29 162.59,35.79 v2(162.59,36.6) 162.59,36.7 PD5.1 ; CZ12.2 150.53,37.98 v2(150.53,37.38) ; v2(93.26,31.66) 93.1,31.5 CX2.2 CX1.2 ; DA1.1 v2(22.64,5.77) ; v2(19.59,7.68) RA16.2 ; CE5.2 v2(43.61,87) ; CE14.2 33.14,64.53 v2(32.98,64.37) ; v2(98.48,49.92) 99.22,49.92 99.83,50.53 RC10.1 ; v2(105.2,112.83) 105.2,112.13 105.7,111.63 CC1.2 CC2.2 ; RC168.2 144.99,74.61 v2(147.1,74.61) ; v2(123.18,43.02) 123.18,43.13 123.48,43.42 RC108.1 ; v2(24.29,37.71) 24.7,37.3 CU12.2 ; PC317.2 19.44,48.19 v2(19.01,47.77) ; CX3.2 CX4.2 91.26,37.31 v2(90.72,37.31) ; RC94.2 CC75.2 93.08,53.37 v2(93.08,52.78) ; ED1.1 v2(224.32,66.1) ; v2(23.08,43.68) 23.08,43.42 PC309.2 ; CA18.2 v2(24.29,10.45) ; CZ18.2 39.09,55.22 v2(38.79,54.92) ; PR6.2 v2(56.98,135.36) ; PCI124.2 127.86,75.37 v2(127.86,75.75) ; EC1.2 v2(219.92,66.05) ; DA5.1 v2(21.05,21.71) ; RC157.2 146.21,82.67 v2(146.34,82.8) ; CT17.2 11.85,119.82 12.1,119.57 v2(12.48,119.57) ; PC2502.2 v2(64.3,115.63) ; v2(210.2,49.73) PQ13.1 209.27,49.98 PR45.2 ; SW1.2 v2(28.03,61.15) ; CA28.2 v2(24.92,6.15) ; YL1.2 15.51,80.68 v2(15.08,81.11) ; RV18.1 128.59,121.15 128.84,121.41 v2(128.84,121.92) ; PRH04.2 166.02,42.79 v2(166.09,42.73) ; v2(17.84,83.99) 17.84,83.96 17.84,83.96 YL1.4 ; RC156.2 v2(145.89,84.96) ; v2(122.91,68.51) 122.91,68.13 PCI128.2 ; v2(67.22,132.33) PRV09.2 ; PCM11.2 v2(50.4,27.96) ; v2(18.7,33.59) 19.15,34.03 CU11.2 ; PC509.2 v2(19.1,103.07) ; CE28.2 v2(55.06,71.8)
  GND1 w0.254: 11.72,61 JUSB1.12 ; JUSB1.12 15.28,61 ; JUSB1.12 13.5,61.88 ; JUSB1.12 15.28,60.12 ; JUSB1.12 11.72,61.88 ; JUSB1.12 15.28,61.88 ; JLAN1.11 2.85,66.42 ; JLAN1.11 4.03,66.42 ; JLAN1.11 1.67,65.75 ; JLAN1.11 4.03,65.08 ; JLAN1.11 4.03,65.75 ; JLAN1.11 2.85,65.08 ; JLAN1.11 1.67,65.08 ; JLAN1.11 1.67,66.42 ; JUSB2.10 15.28,20.52 ; JUSB2.10 15.28,21.4 ; JUSB2.10 15.28,22.28 ; JUSB2.10 11.72,20.52 ; JUSB2.10 11.72,21.4 ; JUSB2.10 13.5,20.52 ; 113.08,98.42 HCPU1.1 ; HCPU1.1 110.69,100.81 ; HCPU1.1 114.82,102.55 ; HCPU1.1 113.08,103.2 ; HCPU1.1 111.34,102.55 ; HCPU1.1 114.82,99.07 ; HCPU1.1 111.34,99.07 ; HCPU1.1 115.47,100.81 ; 99.71,131.94 H10.1 ; H10.1 101.31,132.53 ; H10.1 103.49,130.35 ; H10.1 102.91,131.94 ; H10.1 101.31,128.16 ; H10.1 99.13,130.35 ; H10.1 102.91,128.75 ; H10.1 99.71,128.75 ; JUSB2.13 6.4,37.98 ; JUSB2.13 7.77,37.1 ; JUSB2.13 5.03,37.1 ; JUSB2.13 5.03,37.98 ; JUSB2.13 7.77,37.98 ; 6.9,110.52 H8.1 ; H8.1 8.42,114.12 ; H8.1 8.42,111.08 ; H8.1 8.98,112.6 ; H8.1 5.38,114.12 ; H8.1 5.38,111.08 ; H8.1 6.9,114.68 ; H8.1 4.82,112.6 ; JHDMI1.23 14.03,89.6 ; JHDMI1.23 14.03,90.53 ; JHDMI1.23 14.03,88.67 ; JHDMI1.23 11.47,88.67 ; JHDMI1.23 11.47,90.53 ; JHDMI1.23 12.75,90.53 ; JHDMI1.23 11.47,89.6 ; JHDMI1.23 12.75,88.67 ; 45.5,127.87 H12.1 ; H12.1 46.99,131.39 ; H12.1 46.99,128.41 ; H12.1 43.47,129.9 ; H12.1 47.53,129.9 ; H12.1 44.01,131.39 ; H12.1 45.5,131.93 ; H12.1 44.01,128.41 ; JUSBC1.1 6.6,126.29 ; JUSBC1.1 5.37,125.52 ; JUSBC1.1 7.83,125.52 ; JUSBC1.1 5.37,126.29 ; JUSBC1.1 7.83,126.29 ; JUSBC1.1 7.83,124.74 ; JLAN1.12 10.65,66.42 ; JLAN1.12 9.47,65.08 ; JLAN1.12 9.47,66.42 ; JLAN1.12 11.83,65.08 ; JLAN1.12 9.47,65.75 ; JLAN1.12 10.65,65.08 ; JLAN1.12 11.83,65.75 ; JLAN1.12 11.83,66.42 ; 6.07,41.2 H5.1 ; H5.1 8,39.27 ; H5.1 9.42,42.62 ; H5.1 9.42,39.78 ; H5.1 8,43.13 ; H5.1 6.58,42.62 ; H5.1 9.93,41.2 ; H5.1 6.58,39.78 ; JUSB1.7 14.91,52.62 ; JUSB1.7 14.38,52.48 ; JUSB1.7 13.85,52.62 ; JUSB1.7 15.05,53.15 ; JUSB1.7 13.85,53.68 ; JUSB1.7 14.38,53.82 ; JUSB1.7 14.91,53.68 ; JUSB1.11 7.77,44.42 ; JUSB1.11 6.4,44.42 ; JUSB1.11 5.03,45.3 ; JUSB1.11 5.03,44.42 ; JUSB1.11 7.77,45.3 ; 2.02,105.07 JHDMI1.21 ; JHDMI1.21 2.02,106 ; JHDMI1.21 2.02,106.93 ; JHDMI1.21 4.58,106 ; JHDMI1.21 4.58,105.07 ; JHDMI1.21 4.58,106.93 ; JHDMI1.21 3.3,105.07 ; JHDMI1.21 3.3,106.93 ; 15.35,49.12 JUSB1.4 ; JUSB1.4 16.41,50.18 ; JUSB1.4 15.88,50.32 ; JUSB1.4 15.21,49.65 ; JUSB1.4 15.35,50.18 ; JUSB1.4 16.41,49.12 ; JUSB1.4 16.55,49.65 ; JUSB1.4 15.88,48.98 ; JUSB2.4 16.41,26.28 ; JUSB2.4 16.55,25.75 ; JUSB2.4 16.41,25.22 ; JUSB2.4 15.88,26.42 ; JUSB2.4 15.35,25.22 ; JUSB2.4 15.88,25.08 ; JUSB2.4 15.21,25.75 ; JUSB2.4 15.35,26.28 ; H9.1 144.55,115.58 ; H9.1 145.13,117.18 ; H9.1 142.95,114.99 ; H9.1 144.55,118.77 ; H9.1 142.95,119.36 ; H9.1 141.35,115.58 ; H9.1 141.35,118.77 ; H9.1 140.77,117.18 ; JLAN1.10 4.03,81.88 ; JLAN1.10 1.67,81.88 ; JLAN1.10 4.03,82.55 ; JLAN1.10 2.85,83.22 ; JLAN1.10 4.03,83.22 ; JLAN1.10 2.85,81.88 ; JLAN1.10 1.67,82.55 ; JLAN1.10 1.67,83.22 ; JHDMI1.2 13.18,92.85 ; JHDMI1.2 12.14,92.39 ; JHDMI1.2 12.02,92.85 ; JHDMI1.2 13.06,93.31 ; JHDMI1.2 13.06,92.39 ; JHDMI1.2 12.6,92.26 ; JHDMI1.2 12.14,93.31 ; JUSBC1.6 3.02,116.05 ; JUSBC1.6 3.02,116.88 ; JUSBC1.6 3.02,117.71 ; JUSBC1.6 1.6,117.71 ; JUSBC1.6 1.6,116.05 ; 211.42,63.57 H13.1 ; H13.1 211.42,65.5 ; H13.1 216.28,63.57 ; H13.1 216.28,67.43 ; H13.1 213.85,63.57 ; H13.1 216.28,65.5 ; H13.1 213.85,67.43 ; H13.1 211.42,67.43 ; H4.1 9.83,85.8 ; H4.1 6.48,87.22 ; H4.1 6.48,84.38 ; H4.1 7.9,83.87 ; H4.1 9.32,84.38 ; H4.1 5.97,85.8 ; H4.1 9.32,87.22 ; H4.1 7.9,87.73 ; 1.6,124.69 JUSBC1.5 ; JUSBC1.5 3.02,125.52 ; JUSBC1.5 3.02,124.69 ; JUSBC1.5 3.02,126.35 ; JUSBC1.5 1.6,126.35 ; JUSB2.7 14.91,28.72 ; JUSB2.7 14.38,29.92 ; JUSB2.7 13.85,28.72 ; JUSB2.7 14.38,28.58 ; JUSB2.7 15.05,29.25 ; JUSB2.7 14.91,29.78 ; JUSB2.7 13.85,29.78 ; 3.27,88.63 JHDMI1.22 ; JHDMI1.22 3.27,86.77 ; JHDMI1.22 4.55,86.77 ; JHDMI1.22 3.27,87.7 ; JHDMI1.22 5.83,88.63 ; JHDMI1.22 4.55,88.63 ; JHDMI1.22 5.83,86.77 ; JHDMI1.22 5.83,87.7 ; 5.03,20.52 JUSB2.11 ; JUSB2.11 5.03,21.4 ; JUSB2.11 7.77,20.52 ; JUSB2.11 6.4,20.52 ; JUSB2.11 7.77,21.4 ; 134.99,100.78 HCPU2.1 ; HCPU2.1 139.12,102.52 ; HCPU2.1 139.12,99.04 ; HCPU2.1 137.38,98.39 ; HCPU2.1 135.64,99.04 ; HCPU2.1 137.38,103.16 ; HCPU2.1 139.77,100.78 ; HCPU2.1 135.64,102.52 ; 6.1,116.1 JUSBC1.3 ; JUSBC1.3 6.1,118.11 ; JUSBC1.3 5.38,116.1 ; JUSBC1.3 5.38,118.11 ; JUSBC1.3 6.82,118.11 ; JUSBC1.3 6.82,116.1 ; JUSBC1.3 5.38,117.18 ; JHDMI1.20 14.03,103.17 ; JHDMI1.20 12.75,105.03 ; JHDMI1.20 11.47,104.1 ; JHDMI1.20 11.47,105.03 ; JHDMI1.20 14.03,105.03 ; JHDMI1.20 11.47,103.17 ; JHDMI1.20 14.03,104.1 ; JHDMI1.20 12.75,103.17 ; JHDMI1.17 11.51,100.81 ; JHDMI1.17 10.59,99.89 ; JHDMI1.17 11.63,100.35 ; JHDMI1.17 11.51,99.89 ; JHDMI1.17 10.59,100.81 ; JHDMI1.17 10.47,100.35 ; 10.47,97.35 JHDMI1.11 ; JHDMI1.11 11.63,97.35 ; JHDMI1.11 11.51,97.81 ; JHDMI1.11 11.51,96.89 ; JHDMI1.11 10.59,96.89 ; JHDMI1.11 10.59,97.81 ; JUSB1.10 15.28,46.18 ; JUSB1.10 11.72,44.42 ; JUSB1.10 11.72,45.3 ; JUSB1.10 15.28,44.42 ; JUSB1.10 15.28,45.3 ; JUSB1.10 13.5,44.42 ; 141.55,25.17 H7.1 ; H7.1 143.48,27.1 ; H7.1 142.97,25.68 ; H7.1 139.62,27.1 ; H7.1 142.97,28.52 ; H7.1 140.13,25.68 ; H7.1 140.13,28.52 ; H7.1 141.55,29.03 ; H6.1 208.87,62.43 ; H6.1 207.45,65.78 ; H6.1 207.45,61.92 ; H6.1 206.03,65.27 ; H6.1 205.52,63.85 ; H6.1 209.38,63.85 ; H6.1 206.03,62.43 ; H6.1 208.87,65.27 ; HCPU3.1 114.82,41.55 ; HCPU3.1 114.82,38.07 ; HCPU3.1 113.08,42.19 ; HCPU3.1 113.08,37.42 ; HCPU3.1 111.34,38.07 ; HCPU3.1 111.34,41.55 ; HCPU3.1 115.47,39.81 ; HCPU3.1 110.69,39.81 ; JHDMI1.8 13.06,95.39 ; JHDMI1.8 13.06,96.31 ; JHDMI1.8 12.14,96.31 ; JHDMI1.8 12.02,95.85 ; JHDMI1.8 13.18,95.85 ; JHDMI1.8 12.14,95.39 ; H1.1 8.27,129.08 ; H1.1 5.43,129.08 ; H1.1 8.27,131.92 ; H1.1 6.85,132.43 ; H1.1 6.85,128.57 ; H1.1 5.43,131.92 ; H1.1 4.92,130.5 ; H1.1 8.78,130.5 ; 9.47,81.88 JLAN1.9 ; JLAN1.9 11.83,81.88 ; JLAN1.9 10.65,81.88 ; JLAN1.9 9.47,83.22 ; JLAN1.9 11.83,83.22 ; JLAN1.9 10.65,83.22 ; JLAN1.9 11.83,82.55 ; JLAN1.9 9.47,82.55 ; HCPU4.1 139.12,41.55 ; HCPU4.1 139.12,38.07 ; HCPU4.1 135.64,38.07 ; HCPU4.1 134.99,39.81 ; HCPU4.1 137.38,42.19 ; HCPU4.1 137.38,37.42 ; HCPU4.1 139.77,39.81 ; HCPU4.1 135.64,41.55 ; 5.03,61 JUSB1.13 ; JUSB1.13 6.4,61.88 ; JUSB1.13 7.77,61.88 ; JUSB1.13 7.77,61 ; JUSB1.13 5.03,61.88 ; JUSB2.12 15.28,37.1 ; JUSB2.12 11.72,37.98 ; JUSB2.12 15.28,36.22 ; JUSB2.12 11.72,37.1 ; JUSB2.12 15.28,37.98 ; JUSB2.12 13.5,37.98 ; 124.52,154.54 H11.1 ; H11.1 123.98,153.05 ; H11.1 126.01,155.08 ; H11.1 127.5,154.54 ; H11.1 126.01,151.02 ; H11.1 128.04,153.05 ; H11.1 127.5,151.56 ; H11.1 124.52,151.56 ; JUSBC1.4 7.83,116.88 ; JUSBC1.4 7.83,117.65 ; JUSBC1.4 5.37,116.88 ; JUSBC1.4 6.6,116.1 ; JUSBC1.4 7.83,116.1 ; JUSBC1.4 5.37,116.1 ; JUSBC1.2 6.1,126.3 ; JUSBC1.2 5.38,125.22 ; JUSBC1.2 6.82,124.29 ; JUSBC1.2 6.1,124.29 ; JUSBC1.2 5.38,124.29 ; JUSBC1.2 5.38,126.3 ; JUSBC1.2 6.82,126.3 ; JHDMI1.5 11.63,94.35 ; JHDMI1.5 10.59,94.81 ; JHDMI1.5 10.59,93.89 ; JHDMI1.5 10.47,94.35 ; JHDMI1.5 11.51,93.89 ; JHDMI1.5 11.51,94.81
  VCC w0.203: 11.72,45.3 JUSB1.10 ; JUSB1.10 15.28,46.18 ; JUSB1.10 11.72,44.42 ; JUSB1.10 15.28,44.42 ; JUSB1.10 15.28,45.3 ; JUSB1.10 13.5,44.42 ; JUSB2.10 15.28,22.28 ; JUSB2.10 11.72,20.52 ; JUSB2.10 15.28,20.52 ; JUSB2.10 13.5,20.52 ; JUSB2.10 11.72,21.4 ; JUSB2.10 15.28,21.4 ; 5.03,37.1 JUSB2.13 ; JUSB2.13 5.03,37.98 ; JUSB2.13 6.4,37.98 ; JUSB2.13 7.77,37.98 ; JUSB2.13 7.77,37.1 ; JUSB1.11 7.77,44.42 ; JUSB1.11 5.03,45.3 ; JUSB1.11 7.77,45.3 ; JUSB1.11 5.03,44.42 ; JUSB1.11 6.4,44.42 ; JUSB1.7 15.05,53.15 ; JUSB1.7 14.38,53.82 ; JUSB1.7 13.85,53.68 ; JUSB1.7 14.38,52.48 ; JUSB1.7 14.91,53.68 ; JUSB1.7 13.85,52.62 ; JUSB1.7 14.91,52.62 ; JLAN1.11 2.85,66.42 ; JLAN1.11 2.85,65.08 ; JLAN1.11 4.03,65.08 ; JLAN1.11 1.67,66.42 ; JLAN1.11 4.03,65.75 ; JLAN1.11 1.67,65.75 ; JLAN1.11 1.67,65.08 ; JLAN1.11 4.03,66.42 ; H5.1 9.93,41.2 ; H5.1 8,39.27 ; H5.1 9.42,42.62 ; H5.1 6.58,39.78 ; H5.1 6.58,42.62 ; H5.1 9.42,39.78 ; H5.1 8,43.13 ; H5.1 6.07,41.2 ; JUSB2.12 15.28,37.1 ; JUSB2.12 15.28,37.98 ; JUSB2.12 11.72,37.1 ; JUSB2.12 13.5,37.98 ; JUSB2.12 11.72,37.98 ; JUSB2.12 15.28,36.22 ; 15.88,25.08 JUSB2.4 ; JUSB2.4 15.21,25.75 ; JUSB2.4 16.41,25.22 ; JUSB2.4 15.35,25.22 ; JUSB2.4 15.88,26.42 ; JUSB2.4 16.55,25.75 ; JUSB2.4 16.41,26.28 ; JUSB2.4 15.35,26.28 ; 5.03,20.52 JUSB2.11 ; JUSB2.11 7.77,21.4 ; JUSB2.11 7.77,20.52 ; JUSB2.11 6.4,20.52 ; JUSB2.11 5.03,21.4 ; JUSB1.13 7.77,61.88 ; JUSB1.13 6.4,61.88 ; JUSB1.13 5.03,61 ; JUSB1.13 5.03,61.88 ; JUSB1.13 7.77,61 ; JUSB1.4 15.88,50.32 ; JUSB1.4 16.41,49.12 ; JUSB1.4 15.35,49.12 ; JUSB1.4 16.41,50.18 ; JUSB1.4 15.35,50.18 ; JUSB1.4 16.55,49.65 ; JUSB1.4 15.88,48.98 ; JUSB1.4 15.21,49.65 ; JLAN1.12 11.83,65.08 ; JLAN1.12 9.47,65.08 ; JLAN1.12 9.47,65.75 ; JLAN1.12 10.65,66.42 ; JLAN1.12 11.83,66.42 ; JLAN1.12 11.83,65.75 ; JLAN1.12 9.47,66.42 ; JLAN1.12 10.65,65.08 ; JUSB1.12 15.28,61 ; JUSB1.12 11.72,61 ; JUSB1.12 15.28,61.88 ; JUSB1.12 13.5,61.88 ; JUSB1.12 15.28,60.12 ; JUSB1.12 11.72,61.88 ; 13.85,28.72 JUSB2.7 ; JUSB2.7 14.38,28.58 ; JUSB2.7 14.38,29.92 ; JUSB2.7 15.05,29.25 ; JUSB2.7 14.91,29.78 ; JUSB2.7 14.91,28.72 ; JUSB2.7 13.85,29.78
  VCC w0.254: JLAN1.9 11.83,81.88 ; JLAN1.9 9.47,83.22 ; JLAN1.9 11.83,83.22 ; JLAN1.9 10.65,81.88 ; JLAN1.9 10.65,83.22 ; JLAN1.9 9.47,81.88 ; JLAN1.9 9.47,82.55 ; JLAN1.9 11.83,82.55 ; 6.48,84.38 H4.1 ; H4.1 9.32,84.38 ; H4.1 9.32,87.22 ; H4.1 7.9,83.87 ; H4.1 5.97,85.8 ; H4.1 9.83,85.8 ; H4.1 7.9,87.73 ; H4.1 6.48,87.22 ; 11.47,89.6 JHDMI1.23 ; JHDMI1.23 14.03,90.53 ; JHDMI1.23 11.47,88.67 ; JHDMI1.23 14.03,89.6 ; JHDMI1.23 12.75,90.53 ; JHDMI1.23 14.03,88.67 ; JHDMI1.23 11.47,90.53 ; JHDMI1.23 12.75,88.67 ; JLAN1.10 2.85,83.22 ; JLAN1.10 1.67,81.88 ; JLAN1.10 1.67,82.55 ; JLAN1.10 4.03,82.55 ; JLAN1.10 4.03,83.22 ; JLAN1.10 2.85,81.88 ; JLAN1.10 1.67,83.22 ; JLAN1.10 4.03,81.88 ; JHDMI1.22 4.55,88.63 ; JHDMI1.22 5.83,88.63 ; JHDMI1.22 5.83,86.77 ; JHDMI1.22 5.83,87.7 ; JHDMI1.22 3.27,88.63 ; JHDMI1.22 4.55,86.77 ; JHDMI1.22 3.27,86.77 ; JHDMI1.22 3.27,87.7 ; JUSBC1.6 3.02,117.71 ; JUSBC1.6 3.02,116.88 ; JUSBC1.6 1.6,117.71 ; JUSBC1.6 1.6,116.05 ; JUSBC1.6 3.02,116.05 ; JUSBC1.1 7.83,125.52 ; JUSBC1.1 7.83,124.74 ; JUSBC1.1 5.37,126.29 ; JUSBC1.1 6.6,126.29 ; JUSBC1.1 7.83,126.29 ; JUSBC1.1 5.37,125.52 ; JHDMI1.11 11.51,97.81 ; JHDMI1.11 11.51,96.89 ; JHDMI1.11 10.59,97.81 ; JHDMI1.11 11.63,97.35 ; JHDMI1.11 10.47,97.35 ; JHDMI1.11 10.59,96.89 ; 5.43,131.92 H1.1 ; H1.1 6.85,128.57 ; H1.1 8.27,129.08 ; H1.1 8.78,130.5 ; H1.1 4.92,130.5 ; H1.1 6.85,132.43 ; H1.1 5.43,129.08 ; H1.1 8.27,131.92 ; 12.75,103.17 JHDMI1.20 ; JHDMI1.20 11.47,104.1 ; JHDMI1.20 11.47,105.03 ; JHDMI1.20 11.47,103.17 ; JHDMI1.20 12.75,105.03 ; JHDMI1.20 14.03,105.03 ; JHDMI1.20 14.03,104.1 ; JHDMI1.20 14.03,103.17 ; 5.37,116.88 JUSBC1.4 ; JUSBC1.4 5.37,116.1 ; JUSBC1.4 7.83,117.65 ; JUSBC1.4 7.83,116.1 ; JUSBC1.4 6.6,116.1 ; JUSBC1.4 7.83,116.88 ; 10.47,100.35 JHDMI1.17 ; JHDMI1.17 11.51,100.81 ; JHDMI1.17 10.59,100.81 ; JHDMI1.17 11.63,100.35 ; JHDMI1.17 11.51,99.89 ; JHDMI1.17 10.59,99.89 ; 5.38,114.12 H8.1 ; H8.1 8.42,111.08 ; H8.1 8.42,114.12 ; H8.1 6.9,110.52 ; H8.1 5.38,111.08 ; H8.1 4.82,112.6 ; H8.1 8.98,112.6 ; H8.1 6.9,114.68 ; JHDMI1.21 4.58,106.93 ; JHDMI1.21 4.58,105.07 ; JHDMI1.21 3.3,105.07 ; JHDMI1.21 2.02,105.07 ; JHDMI1.21 3.3,106.93 ; JHDMI1.21 4.58,106 ; JHDMI1.21 2.02,106 ; JHDMI1.21 2.02,106.93 ; 5.38,118.11 JUSBC1.3 ; JUSBC1.3 6.82,118.11 ; JUSBC1.3 6.1,116.1 ; JUSBC1.3 5.38,116.1 ; JUSBC1.3 5.38,117.18 ; JUSBC1.3 6.1,118.11 ; JUSBC1.3 6.82,116.1 ; JHDMI1.5 11.51,94.81 ; JHDMI1.5 11.63,94.35 ; JHDMI1.5 11.51,93.89 ; JHDMI1.5 10.59,94.81 ; JHDMI1.5 10.47,94.35 ; JHDMI1.5 10.59,93.89 ; 12.02,92.85 JHDMI1.2 ; JHDMI1.2 12.14,92.39 ; JHDMI1.2 12.6,92.26 ; JHDMI1.2 13.06,93.31 ; JHDMI1.2 13.18,92.85 ; JHDMI1.2 13.06,92.39 ; JHDMI1.2 12.14,93.31 ; JUSBC1.5 3.02,125.52 ; JUSBC1.5 3.02,124.69 ; JUSBC1.5 1.6,124.69 ; JUSBC1.5 1.6,126.35 ; JUSBC1.5 3.02,126.35 ; 12.14,95.39 JHDMI1.8 ; JHDMI1.8 13.06,95.39 ; JHDMI1.8 12.02,95.85 ; JHDMI1.8 12.14,96.31 ; JHDMI1.8 13.06,96.31 ; JHDMI1.8 13.18,95.85 ; JUSBC1.2 6.82,124.29 ; JUSBC1.2 6.82,126.3 ; JUSBC1.2 5.38,125.22 ; JUSBC1.2 5.38,126.3 ; JUSBC1.2 5.38,124.29 ; JUSBC1.2 6.1,124.29 ; JUSBC1.2 6.1,126.3
  IN3 w0.135: v2(117.96,60.7) 117.56,60.29 117.2,60.29 116.66,59.75
  IN3 w0.254: 116.66,59.75 115.89,58.98 v2(115.59,58.98) 115.4,58.79 115.4,57.23 114.21,56.04 113.06,56.04 109.05,52.03 106.64,52.03 106.18,51.57 106.18,48.83 105.93,48.57 v2(105.89,48.57) 105.43,48.12 103.62,48.12 v2(103.6,48.13) 103.37,48.36 103.37,48.72 104.5,49.86 104.5,52.35 105.79,53.63 108.38,53.63 112.52,57.77 113.38,57.77 113.7,58.09 113.7,58.62 v2(113.34,58.98) 115.63,61.27 v2(115.63,61.62) 117.29,61.62 117.96,60.95 v2(117.96,60.7)
  GND2 w0.254: 142.95,114.99 H9.1 ; H9.1 141.35,115.58 ; H9.1 144.55,115.58 ; H9.1 141.35,118.77 ; H9.1 140.77,117.18 ; H9.1 144.55,118.77 ; H9.1 145.13,117.18 ; H9.1 142.95,119.36 ; 5.03,45.3 JUSB1.11 ; JUSB1.11 7.77,45.3 ; JUSB1.11 5.03,44.42 ; JUSB1.11 6.4,44.42 ; JUSB1.11 7.77,44.42 ; 110.69,39.81 HCPU3.1 ; HCPU3.1 111.34,38.07 ; HCPU3.1 115.47,39.81 ; HCPU3.1 111.34,41.55 ; HCPU3.1 113.08,37.42 ; HCPU3.1 113.08,42.19 ; HCPU3.1 114.82,38.07 ; HCPU3.1 114.82,41.55 ; JUSB1.12 15.28,61 ; JUSB1.12 13.5,61.88 ; JUSB1.12 15.28,60.12 ; JUSB1.12 11.72,61 ; JUSB1.12 11.72,61.88 ; JUSB1.12 15.28,61.88 ; 2.85,81.88 JLAN1.10 ; JLAN1.10 1.67,83.22 ; JLAN1.10 2.85,83.22 ; JLAN1.10 4.03,81.88 ; JLAN1.10 1.67,82.55 ; JLAN1.10 1.67,81.88 ; JLAN1.10 4.03,83.22 ; JLAN1.10 4.03,82.55 ; H10.1 102.91,131.94 ; H10.1 99.71,131.94 ; H10.1 102.91,128.75 ; H10.1 101.31,128.16 ; H10.1 99.71,128.75 ; H10.1 99.13,130.35 ; H10.1 103.49,130.35 ; H10.1 101.31,132.53 ; 15.35,26.28 JUSB2.4 ; JUSB2.4 15.88,26.42 ; JUSB2.4 16.55,25.75 ; JUSB2.4 15.35,25.22 ; JUSB2.4 16.41,25.22 ; JUSB2.4 16.41,26.28 ; JUSB2.4 15.88,25.08 ; JUSB2.4 15.21,25.75 ; HCPU4.1 139.12,38.07 ; HCPU4.1 134.99,39.81 ; HCPU4.1 135.64,38.07 ; HCPU4.1 139.12,41.55 ; HCPU4.1 137.38,42.19 ; HCPU4.1 137.38,37.42 ; HCPU4.1 139.77,39.81 ; HCPU4.1 135.64,41.55 ; H4.1 9.32,84.38 ; H4.1 7.9,87.73 ; H4.1 6.48,84.38 ; H4.1 9.83,85.8 ; H4.1 7.9,83.87 ; H4.1 5.97,85.8 ; H4.1 9.32,87.22 ; H4.1 6.48,87.22 ; JHDMI1.23 14.03,88.67 ; JHDMI1.23 12.75,90.53 ; JHDMI1.23 11.47,89.6 ; JHDMI1.23 11.47,90.53 ; JHDMI1.23 14.03,90.53 ; JHDMI1.23 12.75,88.67 ; JHDMI1.23 11.47,88.67 ; JHDMI1.23 14.03,89.6 ; JUSBC1.3 6.82,116.1 ; JUSBC1.3 5.38,116.1 ; JUSBC1.3 6.1,118.11 ; JUSBC1.3 6.1,116.1 ; JUSBC1.3 6.82,118.11 ; JUSBC1.3 5.38,118.11 ; JUSBC1.3 5.38,117.18 ; 10.59,97.81 JHDMI1.11 ; JHDMI1.11 11.51,96.89 ; JHDMI1.11 11.63,97.35 ; JHDMI1.11 11.51,97.81 ; JHDMI1.11 10.59,96.89 ; JHDMI1.11 10.47,97.35 ; 9.47,83.22 JLAN1.9 ; JLAN1.9 9.47,81.88 ; JLAN1.9 10.65,81.88 ; JLAN1.9 11.83,81.88 ; JLAN1.9 11.83,83.22 ; JLAN1.9 9.47,82.55 ; JLAN1.9 11.83,82.55 ; JLAN1.9 10.65,83.22 ; JHDMI1.21 3.3,106.93 ; JHDMI1.21 2.02,106 ; JHDMI1.21 4.58,106.93 ; JHDMI1.21 3.3,105.07 ; JHDMI1.21 2.02,105.07 ; JHDMI1.21 4.58,106 ; JHDMI1.21 4.58,105.07 ; JHDMI1.21 2.02,106.93 ; 5.43,131.92 H1.1 ; H1.1 6.85,132.43 ; H1.1 8.27,131.92 ; H1.1 8.27,129.08 ; H1.1 5.43,129.08 ; H1.1 6.85,128.57 ; H1.1 8.78,130.5 ; H1.1 4.92,130.5 ; JUSB2.12 15.28,37.1 ; JUSB2.12 11.72,37.1 ; JUSB2.12 13.5,37.98 ; JUSB2.12 15.28,36.22 ; JUSB2.12 15.28,37.98 ; JUSB2.12 11.72,37.98 ; 126.01,151.02 H11.1 ; H11.1 127.5,154.54 ; H11.1 123.98,153.05 ; H11.1 127.5,151.56 ; H11.1 124.52,151.56 ; H11.1 124.52,154.54 ; H11.1 126.01,155.08 ; H11.1 128.04,153.05 ; JUSB2.13 7.77,37.98 ; JUSB2.13 5.03,37.98 ; JUSB2.13 6.4,37.98 ; JUSB2.13 7.77,37.1 ; JUSB2.13 5.03,37.1 ; JLAN1.11 4.03,65.08 ; JLAN1.11 4.03,66.42 ; JLAN1.11 1.67,65.08 ; JLAN1.11 2.85,65.08 ; JLAN1.11 2.85,66.42 ; JLAN1.11 4.03,65.75 ; JLAN1.11 1.67,65.75 ; JLAN1.11 1.67,66.42 ; JUSB2.7 14.38,29.92 ; JUSB2.7 14.91,29.78 ; JUSB2.7 14.38,28.58 ; JUSB2.7 15.05,29.25 ; JUSB2.7 14.91,28.72 ; JUSB2.7 13.85,29.78 ; JUSB2.7 13.85,28.72 ; JUSBC1.2 6.82,124.29 ; JUSBC1.2 5.38,126.3 ; JUSBC1.2 6.82,126.3 ; JUSBC1.2 6.1,124.29 ; JUSBC1.2 5.38,125.22 ; JUSBC1.2 5.38,124.29 ; JUSBC1.2 6.1,126.3 ; JUSBC1.1 7.83,125.52 ; JUSBC1.1 7.83,124.74 ; JUSBC1.1 5.37,126.29 ; JUSBC1.1 6.6,126.29 ; JUSBC1.1 7.83,126.29 ; JUSBC1.1 5.37,125.52 ; 10.65,65.08 JLAN1.12 ; JLAN1.12 9.47,65.08 ; JLAN1.12 9.47,66.42 ; JLAN1.12 9.47,65.75 ; JLAN1.12 10.65,66.42 ; JLAN1.12 11.83,66.42 ; JLAN1.12 11.83,65.08 ; JLAN1.12 11.83,65.75 ; 140.13,28.52 H7.1 ; H7.1 142.97,25.68 ; H7.1 141.55,29.03 ; H7.1 140.13,25.68 ; H7.1 141.55,25.17 ; H7.1 142.97,28.52 ; H7.1 139.62,27.1 ; H7.1 143.48,27.1 ; JHDMI1.20 14.03,105.03 ; JHDMI1.20 12.75,105.03 ; JHDMI1.20 12.75,103.17 ; JHDMI1.20 11.47,105.03 ; JHDMI1.20 14.03,104.1 ; JHDMI1.20 11.47,103.17 ; JHDMI1.20 14.03,103.17 ; JHDMI1.20 11.47,104.1 ; 134.99,100.78 HCPU2.1 ; HCPU2.1 139.12,99.04 ; HCPU2.1 137.38,103.16 ; HCPU2.1 139.12,102.52 ; HCPU2.1 137.38,98.39 ; HCPU2.1 135.64,102.52 ; HCPU2.1 135.64,99.04 ; HCPU2.1 139.77,100.78 ; 10.59,100.81 JHDMI1.17 ; JHDMI1.17 11.51,99.89 ; JHDMI1.17 11.51,100.81 ; JHDMI1.17 10.59,99.89 ; JHDMI1.17 11.63,100.35 ; JHDMI1.17 10.47,100.35 ; 6.4,20.52 JUSB2.11 ; JUSB2.11 5.03,20.52 ; JUSB2.11 5.03,21.4 ; JUSB2.11 7.77,21.4 ; JUSB2.11 7.77,20.52 ; JHDMI1.2 13.18,92.85 ; JHDMI1.2 13.06,93.31 ; JHDMI1.2 13.06,92.39 ; JHDMI1.2 12.6,92.26 ; JHDMI1.2 12.02,92.85 ; JHDMI1.2 12.14,93.31 ; JHDMI1.2 12.14,92.39 ; JUSB1.4 16.41,49.12 ; JUSB1.4 16.55,49.65 ; JUSB1.4 16.41,50.18 ; JUSB1.4 15.35,50.18 ; JUSB1.4 15.88,48.98 ; JUSB1.4 15.35,49.12 ; JUSB1.4 15.88,50.32 ; JUSB1.4 15.21,49.65 ; 44.01,128.41 H12.1 ; H12.1 46.99,128.41 ; H12.1 44.01,131.39 ; H12.1 45.5,127.87 ; H12.1 45.5,131.93 ; H12.1 47.53,129.9 ; H12.1 43.47,129.9 ; H12.1 46.99,131.39 ; 1.6,116.05 JUSBC1.6 ; JUSBC1.6 3.02,116.05 ; JUSBC1.6 3.02,117.71 ; JUSBC1.6 1.6,117.71 ; JUSBC1.6 3.02,116.88 ; H13.1 216.28,67.43 ; H13.1 216.28,63.57 ; H13.1 211.42,65.5 ; H13.1 211.42,63.57 ; H13.1 216.28,65.5 ; H13.1 213.85,67.43 ; H13.1 211.42,67.43 ; H13.1 213.85,63.57 ; 4.82,112.6 H8.1 ; H8.1 8.42,114.12 ; H8.1 5.38,111.08 ; H8.1 5.38,114.12 ; H8.1 8.42,111.08 ; H8.1 6.9,110.52 ; H8.1 6.9,114.68 ; H8.1 8.98,112.6 ; 13.5,44.42 JUSB1.10 ; JUSB1.10 15.28,46.18 ; JUSB1.10 11.72,45.3 ; JUSB1.10 15.28,45.3 ; JUSB1.10 15.28,44.42 ; JUSB1.10 11.72,44.42 ; 13.85,53.68 JUSB1.7 ; JUSB1.7 13.85,52.62 ; JUSB1.7 14.91,53.68 ; JUSB1.7 15.05,53.15 ; JUSB1.7 14.38,53.82 ; JUSB1.7 14.38,52.48 ; JUSB1.7 14.91,52.62 ; 3.27,86.77 JHDMI1.22 ; JHDMI1.22 5.83,86.77 ; JHDMI1.22 5.83,88.63 ; JHDMI1.22 3.27,87.7 ; JHDMI1.22 5.83,87.7 ; JHDMI1.22 3.27,88.63 ; JHDMI1.22 4.55,86.77 ; JHDMI1.22 4.55,88.63 ; HCPU1.1 114.82,102.55 ; HCPU1.1 114.82,99.07 ; HCPU1.1 113.08,103.2 ; HCPU1.1 111.34,102.55 ; HCPU1.1 111.34,99.07 ; HCPU1.1 113.08,98.42 ; HCPU1.1 115.47,100.81 ; HCPU1.1 110.69,100.81 ; 10.59,94.81 JHDMI1.5 ; JHDMI1.5 11.51,94.81 ; JHDMI1.5 10.59,93.89 ; JHDMI1.5 11.51,93.89 ; JHDMI1.5 10.47,94.35 ; JHDMI1.5 11.63,94.35 ; JUSBC1.5 3.02,125.52 ; JUSBC1.5 3.02,124.69 ; JUSBC1.5 1.6,126.35 ; JUSBC1.5 1.6,124.69 ; JUSBC1.5 3.02,126.35 ; JHDMI1.8 13.06,95.39 ; JHDMI1.8 12.14,96.31 ; JHDMI1.8 13.18,95.85 ; JHDMI1.8 13.06,96.31 ; JHDMI1.8 12.14,95.39 ; JHDMI1.8 12.02,95.85 ; H6.1 208.87,65.27 ; H6.1 205.52,63.85 ; H6.1 207.45,65.78 ; H6.1 208.87,62.43 ; H6.1 206.03,65.27 ; H6.1 207.45,61.92 ; H6.1 209.38,63.85 ; H6.1 206.03,62.43 ; 5.03,61 JUSB1.13 ; JUSB1.13 7.77,61 ; JUSB1.13 5.03,61.88 ; JUSB1.13 7.77,61.88 ; JUSB1.13 6.4,61.88 ; 6.07,41.2 H5.1 ; H5.1 9.42,39.78 ; H5.1 6.58,39.78 ; H5.1 8,43.13 ; H5.1 9.42,42.62 ; H5.1 9.93,41.2 ; H5.1 8,39.27 ; H5.1 6.58,42.62 ; 5.37,116.1 JUSBC1.4 ; JUSBC1.4 7.83,116.88 ; JUSBC1.4 5.37,116.88 ; JUSBC1.4 6.6,116.1 ; JUSBC1.4 7.83,117.65 ; JUSBC1.4 7.83,116.1 ; 11.72,21.4 JUSB2.10 ; JUSB2.10 11.72,20.52 ; JUSB2.10 15.28,21.4 ; JUSB2.10 13.5,20.52 ; JUSB2.10 15.28,20.52 ; JUSB2.10 15.28,22.28
  BOTTOM w0.09: v2(121.44,93.2) UC1.B25 ; v2(118.92,93.2) UC1.B29 ; v2(113.34,58.98) UC1.BT36
  BOTTOM w0.102: v2(113.34,71.57) UC1.AT36 ; v2(113.34,66.53) UC1.BD36 ; UC1.L36 114.33,86.66 113.35,86.66 v2(113.34,86.67) ; UC1.CJ11 130.6,51.09 131.07,50.61 131.07,50.21 131.34,49.94 UC1.CM9
  BOTTOM w0.127: UC1.T36 114.33,84.15 113.34,84.15 v2(113.34,84.15) ; v3(136.77,148.74) 136.24,148.2 CV95.2 ; PCI187.2 v3(150.67,58.11) ; UC1.V36 112.58,82.89 v2(112.57,82.9) ; UC1.G36 114.26,89.26 v2(113.42,89.26) ; UC1.CN5 134.03,49.15 133.55,49.63 133.24,49.63 132.78,50.09 v2(132.78,50.45) ; 199.18,61.78 v3(200.16,61.78) ; PCB70.2 v3(185.73,57.03) ; PCI188.2 v3(145.96,90.47) ; v2(157.43,150.59) v3(158.62,150.59) ; v3(99.48,143.82) v2(100.43,143.82) ; PCV172.2 v3(106.18,118.14) ; v2(115.32,110.42) v3(114.52,110.42)
  BOTTOM w0.135: UC1.CM13 129.32,49.64 129.32,49.37 UC1.CN13
  BOTTOM w0.15: v2(117.52,50.08) 117.51,50.09 117.49,50.09 117.16,50.27 116.95,50.27 116.65,50.24 UC1.CM33
  BOTTOM w0.152: UC1.AM33 UC1.AK33 ; UC1.D21 123.93,90.93 ; v2(135.07,80.16) 135.16,80.07 UC1.AB3 ; UC1.AT33 116.19,70.83 116.16,70.8 116.16,70.34 UC1.AV33 ; UC1.D25 121.15,90.61 121.15,90.54 120.96,90.35 UC1.E27 UC1.E29 UC1.E31 UC1.E33 ; UC1.CM4 135.12,49.96 135.42,50.26 136.11,50.26 UC1.CL2 ; UC1.BP32 116.54,60.28 116.52,60.26 116.21,60.26 ; UC1.AV3 UC1.AW1 ; v2(110.33,60.06) 111.61,60.06 111.79,60.24 UC1.BP36
  BOTTOM w0.16: UC1.B31 117.67,92.3 117.67,93.92 v2(117.66,93.93)
  BOTTOM w0.18: UC1.CP15 127.75,47.46 127.77,47.45 v2(127.77,47.22) ; v2(137.69,52.59) 137.69,52.8 137.27,53.22 UC1.CF2 UC1.CF3 ; v2(112.6,87.93) UC1.J36 ; UC1.CB3 UC1.CB2 137.07,55.66 ; v2(112.6,77.87) 112.61,77.86 UC1.AF36 ; UC1.B23 v2(122.7,93.93) ; UC1.CP27 120.27,48.24 120.27,47.39 v2(120.19,47.32) ; UC1.B27 120.18,92.3 v2(120.18,93.93) ; UC1.CP11 130.28,47.45 v2(130.1,47.28) ; v2(112.5,67.82) 112.53,67.79 UC1.BB36 ; v2(112.61,70.31) 112.61,70.31 112.61,70.38 112.69,70.31 UC1.AV36 ; v2(112.61,85.41) UC1.P36 ; UC1.BF36 112.62,65.27 v2(112.56,65.21) ; UC1.AP36 112.61,72.82 v2(112.59,72.85) ; UC1.AB36 v2(112.61,80.37) ; UC1.AK36 v2(112.61,75.34) ; UC1.BK4 134.57,62.97 134.9,62.97 v2(135.04,62.83) 135.2,62.98 UC1.BK3 UC1.BK2
  BOTTOM w0.2: v2(119.24,69.85) UC1.AW28 ; UC1.BD36 UC1.BD35 v2(115.59,66.53) UC1.BD33 ; UC1.CJ28 119.56,50.98 UC1.CM29 ; UC1.BK10 130.41,62.92 130.15,63.18 v2(130.15,63.88) ; v2(117.86,51.68) 117.86,51.78 UC1.CH31 ; UC1.AL28 119.47,74.93 v2(119.24,75.32) UC1.AJ28 ; UC1.CF4 134.61,53.27 135.01,53.27 v2(135.04,53.24) 135.14,53.14 135.48,53.14 UC1.CF3 ; v2(119.87,80.79) UC1.AB27 ; UC1.AM28 119.27,74.35 v2(119.24,74.41) ; v2(130.34,74) UC1.AM10 ; v2(117.97,88.08) UC1.K30 ; UC1.R30 118.22,84.92 117.99,85.35 v2(117.96,85.35) 117.96,85.32 ; v2(118.62,85.37) 118.61,85.34 UC1.R29 ; UC1.BE10 v2(130.35,65.69) ; v2(117.97,84.43) 117.98,84.42 117.98,84.41 ; v2(115.63,61.62) 115.41,61.39 115.09,61.39 UC1.BM35 UC1.BM36 ; UC1.CE36 UC1.CE35 115.04,53.89 v2(115.57,53.89) 115.62,53.95 UC1.CE33 ; UC1.BA28 v2(119.24,68.94) ; UC1.AN31 117.87,73.38 117.92,73.43 v2(117.92,73.45) 117.99,73.38 118.04,73.37 UC1.AN30 ; UC1.C29 UC1.B29 ; v2(130.09,90.35) UC1.F12 ; v2(115.29,90.74) UC1.E35 115.59,90.11 v2(115.67,90.11) ; UC1.BW11 130.37,57.32 130.37,57.88 UC1.BV11 ; v2(121.59,89.74) 122.05,90.02 UC1.F24 ; UC1.AM33 v2(115.59,74.08) UC1.AM35 ; UC1.E33 v2(116.41,90.95) UC1.C33 UC1.B34 ; v2(119.24,70.76) 119.3,70.65 UC1.AV28 ; v2(119.24,56.18) UC1.BY28 ; v2(115.59,84.15) UC1.T35 UC1.T36 ; UC1.BW15 v2(127.39,56.95) UC1.BY15 UC1.CA15 ; UC1.BY36 UC1.BY35 115.61,56.46 v2(115.72,56.58) ; UC1.BE30 118.01,66.13 117.94,66.15 v2(117.92,66.17) 117.92,66.16 117.92,66.15 UC1.BE31 ; v2(118.6,73.5) UC1.AN29 ; v2(130.31,76.75) 130.34,76.77 UC1.AG10 ; v2(126.55,54.35) UC1.CC16 ; UC1.AU28 v2(119.24,71.67) ; UC1.AW31 v2(117.97,69.85) UC1.AW30 ; v2(130.37,82.32) UC1.W10 ; UC1.BE29 v2(118.6,66.21) ; UC1.V27 UC1.U26 UC1.U24 ; UC1.BN30 118.22,61.17 v2(117.96,60.7) ; UC1.CN21 123.97,49.2 124.08,49.31 124.08,49.83 UC1.CM21 ; UC1.K4 UC1.K3 ; UC1.CD24 121.51,54.35 UC1.CC24 ; UC1.AN28 v2(119.24,73.5) ; UC1.CK1 136.93,50.75 137.45,50.22 137.45,50.07 137.62,49.91 v2(137.62,49.84) ; v2(130.08,88.4) UC1.J12 ; v2(118.6,75.32) 118.83,74.93 UC1.AL29 ; v2(130.35,79.54) UC1.AC10 ; v2(124.03,54.35) 124.35,54.6 UC1.CC20 ; v2(117.97,79.87) 117.97,79.86 ; v2(118.6,71.67) UC1.AU29 ; UC1.L33 v2(115.59,86.67) UC1.L35 ; UC1.CJ35 115,51.44 v2(115.66,51.44) ; UC1.AY35 v2(115.59,69.05) UC1.AY33 ; UC1.R27 v2(119.87,85.35) ; 118.17,82.2 117.98,82.54 117.98,82.58 v2(117.88,82.68) ; UC1.AN25 v2(121.71,73.04) ; UC1.AH35 v2(115.59,76.6) ; UC1.AU10 130.34,70.58 v2(130.34,70.29) ; v2(115.59,58.98) UC1.BT33 ; UC1.K31 v2(117.33,88.08) ; UC1.CJ11 v2(130.12,51.08) ; v2(118.6,69.85) UC1.AW29 ; UC1.AF27 v2(119.87,78.05) ; UC1.R28 v2(119.24,85.35) ; v2(119.87,86.26) UC1.N27 ; UC1.K29 v2(118.6,88.08) ; v2(119.87,79.88) UC1.AC27 ; UC1.K27 v2(119.87,87.17) ; UC1.G36 UC1.G35 ; UC1.AT36 UC1.AT35 v2(115.59,71.57) UC1.AT33 ; v2(130.35,85.09) UC1.P10 ; 117.96,80.79 v2(117.96,80.8) ; v2(130.49,68.46) UC1.BA10 ; v2(119.87,84.43) UC1.T27 ; UC1.BE28 119.24,66.21 ; v2(119.24,65.29) UC1.BG28
  BOTTOM w0.203: UC1.CG33 116.19,53 116.41,53.21 116.41,53.73 UC1.CE33 ; v2(113.34,53.95) 113.39,53.99 114.29,53.99 UC1.CE36 ; UC1.Y33 v2(115.68,81.74) UC1.Y35 ; UC1.Y33 116.25,81.69 116.25,82.44 116.19,82.5 UC1.V33 116.22,82.92 116.22,84.12 UC1.T33 ; UC1.Y33 116.24,81.59 116.24,80.42 UC1.AB33 116.23,80.33 116.23,79.16 UC1.AD33 ; UC1.AB30 v2(117.97,79.87) ; UC1.W27 UC1.V26 ; UC1.W27 v2(119.87,82.61) UC1.V27 UC1.V26 ; UC1.W27 v2(119.87,81.7) UC1.Y27 ; UC1.V26 UC1.Y26 UC1.Y27 ; v2(117.32,62.55) UC1.BL32 116.31,61.5 UC1.BM33 ; v2(117.32,62.55) 117.33,62.55 117.33,62.55 UC1.BL31 v2(117.97,62.56) UC1.BL30 ; v2(117.32,62.55) 116.81,62.55 116.6,62.76 UC1.BK33 116.24,62.8 116.24,63.97 UC1.BH33 ; UC1.J18 v2(125.39,88.41) ; 132.78,75.33 132.79,75.37 UC1.AJ7 ; 132.78,75.33 132.75,75.33 132.75,75.24 132.7,75.23 UC1.AL7 v2(132.78,74.46) ; 132.78,75.33 v2(132.81,75.33) ; v2(125.26,47.3) 125.26,47.49 125.22,47.53 125.22,48.31 UC1.CP19 ; v2(115.95,144.7) 116.14,144.51 UV1.AF32 ; UC1.BW24 121.5,56.84 v2(121.5,56.29) ; v2(121.5,56.29) UC1.CA25 v2(121.53,55.69) UC1.CB24 ; v2(121.5,56.29) UC1.BY25 ; UC1.BA3 UC1.AY4 ; UC1.BA3 v2(135.06,67.78) ; UC1.BA3 UC1.BA4 ; UC1.AY4 UC1.BA4 ; UC1.AY4 UC1.AW3 ; v2(119.24,63.47) UC1.BH28 v2(119.16,64.43) ; v2(119.24,63.47) UC1.BH29 ; v2(119.24,63.47) UC1.BK28 v2(119.24,62.56) ; UC1.BR22 123.24,59.59 v2(123.24,59.56) ; UC1.N25 UC1.N27 v2(119.87,85.35) UC1.R28 v2(119.87,84.43) ; UC1.AF27 v2(119.87,77.14) UC1.AH28 ; UC1.AE7 132.59,78.54 v2(132.78,78.16) UC1.AF7 132.79,77.21 v2(132.8,77.21) ; UC1.BY22 UC1.CA22 v2(124.01,55.65) UC1.CB20 v2(123.99,55.01) 124.23,54.83 UC1.CC20 ; UC1.B12 v2(130.08,92.3) ; UC1.BH33 v2(116.65,64.41) ; UC1.BH33 v2(115.62,64.01) UC1.BH35 ; v2(116.65,64.41) 116.19,64.86 UC1.BF33 116.26,65.35 116.26,66.46 UC1.BD33 116.21,66.55 116.21,67.77 UC1.BB33 116.24,67.84 116.24,69 UC1.AY33 116.3,69.16 116.3,70.2 UC1.AV33 ; v2(116.65,64.41) UC1.BH32 ; UC1.CC25 UC1.CB25 ; 118.17,82.2 UC1.W30 v2(117.93,81.73) 117.94,81.72 117.94,81.71 ; v2(135.06,67.78) UC1.BB4 134.02,68.01 v2(134.02,68.01) 134.56,68.52 UC1.BA4 ; v2(135.06,67.78) UC1.BB3 ; v2(132.78,50.45) UC1.CK7 ; 130.32,54.02 130.21,54.02 v2(129.91,54.32) ; 130.32,54.02 UC1.CD11 ; 130.32,54.02 v2(129.95,53.66) ; UC1.BE4 UC1.BF4 v2(135.07,65.28) ; UC1.BE4 UC1.BD4 ; UC1.BE4 v2(134.06,66.17) 133.43,66.17 v2(133.42,66.15) UC1.BD6 v2(132.78,66.15) UC1.BD7 v2(132.15,67.07) UC1.BC8 ; UC1.BE4 UC1.BE3 UC1.BD4 ; UC1.BM33 116.07,61.62 v2(115.63,61.62) ; UC1.BM33 116.21,61.48 116.21,61.03 116.21,60.26 UC1.BP33 116.19,59.87 116.22,59.83 116.22,59.01 UC1.BT33 ; UC1.AK4 134.72,75.35 135.23,75.35 135.4,75.19 UC1.AK3 135.96,74.93 136.05,74.87 136.7,74.87 136.91,74.66 136.91,74.21 136.91,74.15 v2(137.1,73.96) ; v2(119.16,64.43) 118.87,63.94 UC1.BH29 ; v2(119.16,64.43) UC1.BG28 ; UC1.CN9 131.36,48.88 131.36,48.59 UC1.CP9 131.43,48.31 131.43,47.57 v2(131.44,47.56) ; UC1.BC29 v2(118.6,68.03) ; UC1.BC29 v2(119.22,68.04) ; UC1.BC29 v2(119.24,67.12) UC1.BD28 119.24,66.21 ; UC1.AP3 135.13,72.83 v2(135.06,72.93) 134.99,72.83 UC1.AP4 134.56,72.13 UC1.AR4 134.6,71.85 UC1.AT4 134.92,71.29 UC1.AU4 134.6,70.35 UC1.AV4 ; UC1.CD20 v2(124.03,54.35) ; v2(132.58,137.61) 132.33,137.61 UV1.F22 ; UC1.Y27 v2(119.87,80.79) ; UC1.CD25 121.51,54.35 ; UC1.BA6 v2(133.42,68) ; UC1.H9 v2(131.02,87.75) UC1.K9 ; v2(129.91,54.32) 129.52,54.02 UC1.CD12 v2(129.95,53.66) ; v2(129.91,54.32) UC1.CC11 ; UC1.BY11 130.34,56.67 130.85,56.92 v2(130.85,56.93) ; UC1.BY11 UC1.BW11 ; UC1.BY11 UC1.CA11 130.82,55.97 v2(130.84,56) ; UC1.BY33 116.24,56.51 116.24,57.68 UC1.BV33 ; UC1.CC28 v2(119.84,54.4) ; UC1.BL28 v2(119.24,62.56) ; v2(119.24,62.56) UC1.BL29 v2(118.6,62.56) UC1.BL30 ; 120.53,59.97 v2(120.54,59.95) ; 120.53,59.97 UC1.BP25 120.8,60.66 120.52,60.66 v2(120.46,60.72) ; 120.53,59.97 120.59,59.97 120.68,59.87 UC1.BR25 121,59.78 121,59.31 UC1.BT25 121.02,59.16 121.02,58.63 UC1.BU25 120.59,58.08 120.59,57.79 v2(120.59,57.79) ; v2(116.7,68.04) UC1.BC32 ; v2(119.24,85.35) UC1.R29 ; UC1.P3 135.16,84.95 v2(135.06,84.86) 134.97,84.95 UC1.P4 ; UC1.BY5 133.85,56.24 134.05,56.03 134.21,56.03 v2(134.21,56.03) 134.21,56.01 UC1.CB4 UC1.CB3 ; UC1.B18 v2(125.38,92.28) ; v2(124.06,58.24) 124.07,58.28 UC1.BU20 v2(124.87,58.25) ; v2(123.22,58.22) UC1.BU23 UC1.BU24 ; UC1.AN8 132.12,72.63 132.14,72.63 v2(132.15,72.6) ; v2(125.12,106.62) 125.13,106.61 UZ1.11 ; UC1.AU29 v2(119.24,71.67) UC1.AR28 v2(119.24,72.59) UC1.AN28 ; UC1.CJ28 119.51,51.46 v2(119.34,51.63) ; v2(121.77,50.49) 121.68,50.38 121.61,50.37 121.43,50.15 UC1.CM25 UC1.CN25 ; UC1.B7 132.71,92.89 132.64,92.94 v2(132.64,92.98) ; UC1.BG25 v2(121.79,64.84) ; UC1.E23 UC1.F24 ; UC1.AN7 v2(132.78,72.62) ; v2(128.19,88.43) 128.13,88.39 UC1.J15 ; UC1.Y30 v2(117.96,80.8) ; UC1.BT5 v2(134.08,58.72) UC1.BV4 UC1.BV3 ; UC1.CF14 128.53,53.51 v2(128.25,53.74) 128.27,53.74 UC1.CD14 UC1.CC14 128.19,54.96 v2(128.19,54.99) ; v2(114.25,93.16) UC1.A36 114.54,92.45 UC1.B36 ; v2(132.88,56.97) 132.73,57.02 UC1.BW7 ; v2(131.02,91.65) UC1.C9 ; UC1.T33 v2(115.59,84.15) ; UC1.T33 116.22,84.18 116.22,85.38 UC1.P33 116.19,85.77 116.22,85.8 116.22,86.63 UC1.L33 116.24,86.71 116.24,86.99 116.24,87.88 UC1.J33 116.24,87.97 116.24,89.09 UC1.G33 UC1.F33 ; UC1.CN13 UC1.CP13 129.01,47.71 v2(129.05,47.68) ; UC1.BP15 v2(127.37,60.18) UC1.BR16 ; UC1.CR36 114.01,47.99 113.71,47.7 v2(113.71,47.04) ; v2(121.59,89.74) 121.51,90.36 UC1.D25 UC1.C25 UC1.B25 ; UC1.BY18 UC1.BY19 v2(124.87,56.3) ; v2(133.87,92.92) 133.83,92.88 133.9,92.4 UC1.B5 UC1.C4 v2(133.99,91.2) 133.99,90.69 UC1.D5 UC1.D6 ; UC1.AM33 116.27,74 116.27,72.91 UC1.AP33 116.19,72.37 116.57,72 116.57,71.99 116.69,71.87 v2(116.69,71.67) ; v2(132.78,80.01) UC1.AB7 v2(132.79,80.94) 132.56,81.39 UC1.Y7 v2(132.78,81.85) UC1.W7 v2(132.78,82.78) UC1.U7 v2(132.78,83.7) UC1.T7 v2(132.78,84.63) UC1.P7 ; v2(121.83,62.16) 121.77,62.1 UC1.BL25 ; v2(133.44,80.03) 133.44,79.9 133.8,79.54 UC1.AC5 134.04,79.74 v2(134.04,80.02) 134.09,80.07 UC1.AB4 ; UC1.BF3 v2(135.07,65.28) ; v2(135.07,65.28) UC1.BG4 ; UC1.BT16 v2(127.36,58.85) ; v2(127.36,58.85) UC1.BT15 128.13,58.97 v2(128.23,58.9) UC1.BT14 ; v2(127.36,58.85) UC1.BU16 v2(126.55,58.25) ; v2(134.05,67.07) UC1.BC4 UC1.BD4 ; UC1.L36 UC1.L35 ; v2(129.95,53.66) 129.96,53.65 129.96,53.65 UC1.CF11 ; UC1.BV11 130.39,57.99 130.39,58.51 UC1.BU11 130.45,58.7 130.74,58.7 v2(130.84,58.6) ; v2(136.5,46.98) 136.41,47.07 136.41,47.46 136.09,47.78 UC1.CR2 136.09,48.45 UC1.CP2 ; UC1.T27 120.17,83.98 UC1.U26 ; UC1.BH29 v2(118.56,64.4) ; v2(113.4,61.58) 114.26,61.58 UC1.BM36 ; UC1.CB7 132.55,55.53 132.57,55.51 132.75,54.98 132.56,54.61 UC1.CC7 132.78,54.14 UC1.CE7 v2(132.78,53.22) UC1.CG7 ; UC1.K4 v2(134.04,87.39) UC1.J5 v2(133.42,87.4) ; UC1.AD35 v2(115.65,79.12) UC1.AD33 ; UC1.BP7 132.78,60.61 UC1.BN7 v2(132.15,61.53) ; UC1.BT36 UC1.BT35 v2(115.59,58.98) ; UC1.AD33 116.22,79.09 116.22,77.88 UC1.AF33 116.34,77.71 116.34,76.74 UC1.AH33 ; v2(115.59,76.6) UC1.AH33 ; UC1.AH33 116.19,76.18 116.22,76.15 116.22,75.75 116.19,75.73 UC1.AK33 v2(116.7,75.33) 116.88,74.93 UC1.AL32 ; JKB1.30 82.95,33.4 v2(82.56,33) ; UC1.AH29 v2(118.6,77.14) UC1.AH30 v2(117.97,77.14) UC1.AF30 v2(117.92,77.99) UC1.AE30 ; v2(133.42,85.55) UC1.N6 v2(133.42,86.47) UC1.L6 v2(133.42,87.4) ; v2(117.33,88.08) 116.91,87.66 UC1.K32 ; UC1.AM28 v2(119.24,73.5) UC1.AN29 ; UC1.AW3 UC1.AW4 v2(134.05,69.85) UC1.AV4 ; UC1.AW3 v2(135.05,70.18) ; UC1.CB18 v2(125.71,55) UC1.CB19 ; UC1.E33 UC1.F33 ; UC1.F33 v2(115.67,90.11) ; v2(137.44,48.03) 137.11,48.35 137.11,48.69 136.69,49.1 UC1.CN1 136.22,49.43 UC1.CN2 ; UC1.K27 v2(119.83,88.07) ; v2(119.83,88.07) UC1.K28 ; v2(119.83,88.07) UC1.H27 v2(119.84,89) UC1.G27 v2(119.82,89.88) UC1.E27 ; v2(132.15,61.53) 132.15,61.53 UC1.BM9 ; v2(132.15,61.53) 132.45,61.88 UC1.BL7 ; UC1.AV25 v2(121.71,70.31) ; UC1.D9 UC1.E9 131.03,89.71 v2(131.03,89.7) 131.44,89.26 UC1.G9 ; UC1.D9 v2(131.03,91.04) ; UC1.D9 UC1.D8 v2(132.15,90.17) ; UC1.E29 v2(118.92,90.95) UC1.C29 ; UC1.J6 v2(133.42,87.4) ; v2(137.13,46.98) 136.88,47.24 136.88,47.48 136.55,47.82 UC1.CP1 ; UC1.AW1 136.68,69.78 v2(137.1,69.78) ; UC1.AV28 v2(119.24,69.85) UC1.AW29 ; UC1.BL30 UC1.BN30 ; UC1.CN17 126.7,49.49 v2(126.75,49.5) 126.7,49.52 UC1.CM17 ; UC1.BR19 125.37,59.86 v2(125.75,60.18) 125.35,60.53 UC1.BP19 ; UV1.AH32 v2(114.2,143.86) ; v2(119.87,78.05) UC1.AE27 ; v2(116.69,71.67) UC1.AT33 ; v2(116.69,71.67) UC1.AU32 ; UC1.AB27 v2(119.87,79.88) ; v2(118.6,88.08) UC1.K30 ; UC1.CN21 UC1.CP21 124.1,48.28 124.1,47.75 124.49,47.36 124.49,46.76 v2(124.39,46.66) ; UC1.BT28 v2(119.24,58.91) ; v2(128.19,92.3) 128.13,92.26 UC1.B15 ; v2(134.13,82.8) UC1.V4 UC1.V3 ; v2(119.24,75.32) 118.91,74.93 UC1.AL29 v2(119.24,74.41) ; UC1.BJ7 132.78,63.41 132.78,63.39 v2(132.79,63.39) UC1.BK7 ; v2(119.24,70.76) UC1.AU28 ; v2(134.41,89.72) UC1.F4 UC1.F3 ; UC1.A32 v2(116.91,93.13) ; UC1.F15 v2(127.27,90.36) ; v2(119.87,87.17) UC1.L27 v2(119.87,86.26) ; v2(128.84,121.92) 128.94,122.02 UV1.K2 ; v2(135.05,70.18) UC1.AV4 ; v2(135.05,70.18) UC1.AV3 ; UC1.CM4 134.71,49.94 UC1.CM5 ; UC1.R30 v2(117.97,84.43) UC1.R31 ; UC1.CF19 124.95,52.99 v2(124.94,52.97) ; UC1.J24 v2(121.59,87.84) UC1.K24 v2(122.71,87.2) UC1.K22 v2(123.64,87.17) UC1.K21 v2(123.65,87.78) UC1.J21 v2(123.63,88.37) UC1.H21 v2(123.66,89.02) UC1.G21 UC1.F21 UC1.D21 ; v2(132.15,65.23) UC1.BE8 ; UC1.K31 v2(117.97,88.08) ; UC1.AV8 v2(132.15,69.85) ; v2(150.21,35.86) 150.15,35.8 147.81,35.8 JDB1.12 ; UC1.BP12 v2(129,60.9) ; UC1.CN29 UC1.CM29 ; UC1.F18 v2(125.37,90.35) ; v2(135.05,132.75) 134.89,132.91 134.67,132.91 134.58,133 UV1.B16 ; v2(115.29,90.74) 114.69,91.34 UC1.C36 UC1.C37 UC1.B37 v2(113.64,92.62) ; UC1.AV6 v2(132.78,69.85) ; UC1.AW28 v2(119.24,68.94) ; v2(117.52,50.08) 117.57,50.05 UC1.CM31 ; v2(119.87,78.97) UC1.AC27 ; UC1.V30 v2(117.88,82.68) ; v2(118.6,66.21) UC1.BE30 ; UC1.AW30 v2(118.6,69.85) ; UC1.BC25 v2(121.74,67.57) ; v2(117.89,57.08) 117.89,57.22 UC1.BV31 ; v2(118.6,73.5) UC1.AN30 ; v2(119.24,88.08) UC1.K29
  BOTTOM w0.22: UV1.B20 134.53,136.2 v2(134.64,136.31) ; UV1.B22 134.44,137.8 v2(135,138.36) ; v2(134.68,131.38) 134.66,131.4 UV1.B14 ; v2(135.04,134.6) UV1.B18 ; v2(134.5,129.48) 134.18,129.8 UV1.B12
  BOTTOM w0.25: UV1.H17 130.73,134 131.35,134.62 131.37,134.62 v2(131.39,134.64) ; v2(134.62,139.38) 134.6,139.38 134.6,139.4 UV1.B24 ; UV1.G31 131.35,143.81 131.35,143.88 131.16,144.07 131.16,144.45 v2(131.63,144.92) ; v2(134.13,141.48) 134.14,141.48 UV1.B26
  BOTTOM w0.254: JSSD1.15 35.87,35.06 v2(35.67,35.26) ; UV1.AD32 v2(117.74,144.82) ; v2(157.9,138.33) 157.91,138.33 158.31,137.93 UV13.E3 ; v2(128.02,51.36) 128.05,51.36 128.05,51.37 128.05,51.37 128.44,51.37 UC1.CJ14 ; UV13.M10 v2(153.12,143.12) 153.51,143.51 UV13.L10 ; UC1.CR36 UC1.CP37 ; PCW10.2 141.74,111.2 142.45,110.49 PUW01.8 ; UV15.L10 153.48,126.51 v2(153.12,126.88) 153.1,126.88 152.73,126.51 UV15.M10 ; UV13.A14 161.51,146.73 161.12,147.12 v2(161.12,147.13) ; v2(150.16,147.24) 150.31,147.09 UV13.R14 ; UC1.CC24 UC1.CB24 ; v2(117.39,140.61) 117.74,140.26 UV1.AD25 UV1.AC24 ; UV1.P6 125.6,125 125.07,125.54 v2(124.94,125.54) ; UV13.N12 v2(152.31,145.53) ; UV15.G10 156.73,126.51 v2(157.12,126.12) UV15.F10 ; UV13.K13 154.31,145.94 154.72,146.36 ; UV15.N1 v2(152.34,118.88) ; UV15.T10 149.57,126.51 v2(149.95,126.88) ; UV1.H2 130.53,122.99 130.53,122.13 v2(130.45,122.05) ; UV13.T5 v2(149.1,139.94) ; 136.13,92.79 v2(136.18,92.84) ; 136.13,92.79 136.09,92.75 UC1.B2 ; 136.13,92.79 135.79,92.79 UC1.A3 UC1.A4 ; UV1.L27 128.14,142.04 v2(127.86,142.32) ; JSSD1.9 v2(37.38,35.68) ; v2(127.34,124.48) 127.34,124.49 UV1.M6 ; UV13.A12 161.51,145.13 161.91,144.73 v2(161.92,144.73) ; v2(132.98,47.33) 133.03,47.33 133.46,47.76 UC1.CR6 ; UT1.12 v2(29,119.81) ; UV13.R11 150.31,144.32 v2(149.91,143.93) 149.51,143.53 UV13.T10 ; v2(115.66,51.44) 116.18,51.49 UC1.CJ33 ; UC1.BW7 132.42,57.5 132.42,58.17 UC1.BU7 ; UV13.M5 152.72,139.53 v2(153.12,139.93) 153.51,139.54 UV13.L5 ; v2(151.91,130.29) 151.91,130.26 UV15.N14 ; UV1.H14 130.43,131.6 130.04,131.99 130.04,132.29 v2(130.06,132.29) ; UV15.N12 v2(152.31,127.71) ; UV15.R4 150.26,121.71 v2(149.86,121.31) 150.26,120.91 UV15.R3 ; UV13.R1 150.31,136.22 150,135.91 v2(150,135.78) ; UV15.M5 153.1,122.12 v2(153.12,122.12) UV15.L5 ; v2(158.7,143.93) 158.71,143.93 159.11,143.53 UV13.D10 ; v2(160.02,135.76) 159.91,135.87 UV13.C1 ; UC1.AC30 v2(117.97,78.93) 118.19,78.54 UC1.AE30 ; v2(161.12,138.33) 161.12,138.32 161.51,137.93 UV13.A3 ; UC1.CB7 132.55,55.74 v2(132.81,56) ; UC1.CF28 119.78,52.72 v2(119.78,52.54) ; v2(160.06,118.79) 159.91,118.95 UV15.C1 ; UV1.F6 132.17,125 v2(132.51,124.66) ; UV13.K2 UV13.K1 154.31,135.76 v2(154.31,135.76) ; UV15.K13 UV15.K14 154.31,130.2 v2(154.34,130.23) ; v2(132.62,115.13) 132.62,115.15 132.87,115.41 UZ5.5 ; v2(121.8,53.11) 121.87,53.19 UC1.CF23 122.33,53.61 UC1.CD24 ; UC1.F3 UC1.F2 136.65,89.83 v2(136.71,89.89) ; UV1.G8 131.44,126.49 132.04,126.49 UV1.F8 132.37,126.6 132.42,126.55 132.61,126.55 v2(132.63,126.53) ; UC1.BP4 135.01,60.54 v2(135.04,60.57) 135.07,60.54 UC1.BP3 ; v2(137.13,46.98) 137.64,46.98 140.24,44.38 141.46,44.38 141.72,44.64 RC86.2 142.27,45.14 143.75,43.67 RC12.1 ; v2(156.28,146.35) 156.28,146.36 UV13.H14 ; v2(119.72,124.63) 119.35,125 UV1.AB6 ; v2(112.49,143) 111.57,143 109.98,144.58 107.27,144.58 105.6,142.91 105.6,139.3 105.88,139.02 109.3,139.02 109.68,139.4 109.68,139.51 CV18.2 109.46,139.56 108.97,140.04 YV1.2 ; UV13.G5 156.71,140.09 v2(156.71,140.09) ; UV15.C3 v2(160.32,120.5) ; v2(150.2,130.27) 150.31,130.17 UV15.R14 ; UV15.E12 v2(157.95,128.47) ; v2(132.52,136.62) 132.52,136.58 UV1.F20 ; UC1.CC11 130.42,54.67 v2(130.87,55.07) 130.85,55.06 UC1.CB11 ; UV13.N14 151.91,147.24 v2(151.9,147.25) ; UV1.F10 132.1,128.2 v2(131.7,127.79) 131.34,128.15 UV1.G10 ; UV15.K1 154.31,119.32 v2(153.91,119.71) UV15.K2 ; v2(149.11,144.73) 148.71,145.13 UV13.U12 ; UV13.K14 154.33,146.73 154.7,146.36 154.72,146.36 ; v2(135.12,126.29) 134.96,126.29 134.65,126.6 UV1.B8 ; v2(119.7,144.76) 119.7,144.56 UV1.AB32 ; 154.72,146.36 v2(154.73,146.36) ; v2(131.39,134.64) 132.1,134.64 UV1.F18 ; v2(128.45,143.37) 128.45,143.35 128.7,143.09 128.7,142.9 128.94,142.66 UV1.K28 ; v2(112.71,141.77) 112.41,141.77 v2(110.59,139.95) ; UV15.U3 v2(148.29,120.49) ; v2(158.33,135.76) 158.31,135.78 UV13.E1 ; v2(151.46,126.88) 151.11,126.53 UV15.P10 ; UV1.AA27 120.1,141.83 v2(120.1,142.32) ; v2(148.18,147.25) UV13.U14 ; v2(132.15,121.99) 132.13,121.99 132.13,122.99 UV1.F2 ; UV1.P32 125.01,144.2 v2(124.8,144.41) ; UV15.R11 v2(149.91,127.71) UV15.R12 ; UC1.B9 131.54,92.16 v2(131.02,91.65) ; UV15.A1 161.51,119.31 v2(161.88,118.94) ; v2(185.17,34.02) 185.17,33.53 183.63,31.98 JHDD1.14 ; UV13.N1 151.91,135.94 v2(151.72,135.76) ; UV1.AE27 v2(117.33,141.4) ; UV15.H1 v2(155.91,118.74) ; UV13.A1 161.51,136.33 v2(161.91,135.93) ; v2(156.37,93.1) PUG01.14 ; UV15.A14 161.51,129.76 v2(161.17,130.1) ; UV1.AD8 117.75,126.6 v2(118.11,126.24) ; UV13.F10 157.11,143.13 v2(157.1,143.13) 157.1,143.14 UV13.G10 ; v2(126.35,144.69) 126.84,144.2 UV1.M32 ; 137.07,55.66 v2(137.07,55.66) ; UV13.C3 159.91,137.93 v2(160.31,138.33) 159.91,138.73 UV13.C4 ; v2(113.32,50.83) 113.81,50.83 UC1.CK37 113.92,51.01 UC1.CJ36 ; UV13.H13 155.91,145.93 v2(156.31,145.53) ; v2(131.28,142.5) 131.28,141.86 UV1.G27 ; UV13.C14 159.91,146.73 160.31,146.33 v2(160.31,146.33) ; v2(121.53,55.69) 121.16,55.32 UC1.CB25 ; v2(113.06,48.91) 113.26,49.1 UC1.CN37 UC1.CM37 ; UC1.CJ23 121.84,51.08 v2(121.76,51.12) ; v2(157.9,139.13) 157.9,139.14 157.51,139.53 UV13.F5 ; UV13.U3 148.71,137.93 v2(149.11,138.33) 149.91,138.33 UV13.R4 ; UV1.E28 132.52,142.18 v2(132.52,142.1) 132.52,141.54 132.14,141.16 UV1.F26 ; v2(211.36,47.81) 211.36,49.21 211.6,49.45 JEDP1.23 ; UV13.H2 UV13.H1 156.14,136.09 v2(156.14,135.8) ; UV13.U1 v2(148.71,135.81) ; UV1.T6 124.14,125 v2(124.49,124.65) ; UV13.B10 160.71,143.53 160.31,143.93 v2(160.31,143.93) ; UV15.H2 v2(155.51,119.71) ; UC1.CM4 134.56,50.14 UC1.CK4 134.56,51.4 UC1.CJ4 UC1.CJ3 UC1.CJ2 ; UV1.J31 129.74,144.29 v2(129.66,144.37) 129.12,144.37 UV1.K32 ; v2(157.9,145.53) 158.3,145.13 UV13.E12 ; UC1.AG5 v2(134.19,76.26) ; v2(115.72,56.58) UC1.BY33 ; UC1.AF3 135.36,77.83 134.76,77.83 UC1.AF4 134.5,77.63 v2(134.19,77.32) ; UV15.N3 v2(152.32,120.49) ; UV15.R1 150.3,119.31 v2(149.92,119.69) ; v2(135.49,128.16) 135.12,128.16 135.08,128.2 UV1.B10 ; UV1.AD6 117.69,125 v2(117.29,125.4) 116.94,125.75 UV1.AE7 ; UV15.C4 v2(160.32,121.29) ; UV15.C14 159.91,130.05 v2(160.18,130.33) ; v2(150.71,144.73) UV13.R12 ; v2(160.31,139.93) 160.71,139.53 UV13.B5 ; v2(124.88,50.99) 125,50.99 125.26,51.24 UC1.CJ19 ; v2(114.54,47.22) 114.93,47.61 115.21,47.61 115.59,47.99 UC1.CR34 115.68,48.03 115.19,48.51 UC1.CP35 ; UC1.AM5 v2(134.06,73.54) ; UV15.C12 v2(159.51,128.51) ; v2(151.52,143.11) UV13.P10 ; v2(150.72,137.53) 150.32,137.93 UV13.R3 ; UV15.C11 160.31,127.71 161.11,127.71 v2(161.15,127.75) UV15.A12 ; UV13.C11 159.91,144.33 160.31,144.72 v2(160.31,144.73) 160.31,144.73 159.91,145.13 UV13.C12 ; v2(124.5,144.99) 124.14,144.63 UV1.T32 ; UC1.CC31 117.56,54.93 v2(117.26,55.23) 116.21,55.23 UC1.CB33 ; v2(157.91,147.13) 158.31,146.73 UV13.E14 ; UV1.A30 135.09,143.4 135.13,143.36 v2(135.13,143.39) ; UV15.B5 v2(161.14,122.08) ; UV1.C32 134.13,144.59 v2(134.13,144.62) ; UV15.G5 v2(157.12,122.92) 157.51,122.53 UV15.F5 ; v2(162.08,120.61) 161.81,120.61 161.51,120.91 UV15.A3 ; v2(156.22,130.15) 156.22,130.02 UV15.H14 155.97,129.65 155.97,128.97 UV15.H13 ; v2(131.73,130.99) UV1.F14 ; UV1.B6 133.86,124.72 v2(133.75,124.72) ; UV15.T5 v2(149.87,122.15) ; v2(158.32,118.78) 158.32,119.04 158.32,119.03 158.32,119.3 UV15.E1 ; v2(134.15,122.23) 133.78,122.6 UV1.C1 ; UV15.D10 v2(159.51,126.91) ; UV15.B10 v2(160.33,126.13) ; UV1.J27 v2(129.74,142.45) ; UV15.U1 v2(149.15,118.87) ; v2(136.93,92.1) 136.55,91.71 UC1.C1 UC1.D1 ; UC1.CL2 136.13,50.17 UC1.CM1 139.73,46.57 CC9.2 142.66,45.97 143.16,45.46 v2(144.31,45.46) 144.41,45.57 146.47,45.57 146.72,45.82 146.72,49.59 146.53,49.78 v2(143.98,49.78) 143.23,49.78 142.97,49.53 142.97,48.99 CC10.2 139.76,48.67 138.97,49.46 138.97,49.66 v2(137.64,50.99) ; PUH01.8 163.42,45.52 163.48,45.58 v2(163.67,45.58) 163.67,45.97 163.78,46.08 163.78,46.08 163.93,46.24 PCH10.2 ; UV15.U14 v2(148.24,130.17) ; v2(157.9,130.15) 157.9,130.12 UV15.E14 ; v2(152.31,137.53) 151.91,137.93 UV13.N3 ; UV15.U12 v2(149.11,127.71) ; UV1.R27 125.11,141.8 125.51,142.19 126.15,142.19 UV1.N27 ; UV15.E3 v2(157.91,120.51)
  BOTTOM w0.3: v2(114.79,128.7) 114.79,128.45 UV1.AH10 ; v2(129.37,124.61) 129.33,124.61 UV1.K6 ; UV1.V32 123.17,144.2 v2(123.57,144.59) ; UV1.F24 132.51,139.42 v2(132.63,139.31) ; UV1.F12 132.14,129.78 v2(132.58,129.34)
  BOTTOM w0.305: v2(121.37,142.18) 121.74,141.81 UV1.W27 ; JDIMM1.243 77.75,47.49 v2(77.72,47.52) ; v2(114.79,128.7) 114.79,129.25 UV1.AG12 ; JSSD1.39 29.87,34.93 v2(30.07,35.12) ; v2(33.77,31.58) 34.38,32.19 JSSD1.21 ; v2(118.14,142.11) 118.21,142.05 118.29,142.05 UV1.AC27 ; JEDP1.13 213.17,54.45 v2(213.27,54.35) ; v2(122.67,126.96) 123.1,127.4 UV1.U9 ; v2(213.31,52.52) 213.21,52.52 213.14,52.45 JEDP1.17 ; v2(70.28,125.12) 70.49,124.9 JWLAN1.18 ; v2(130.21,126.21) 129.8,125.8 UV1.J7 UV1.H6 ; v2(26.39,36.25) 26.06,36.25 25.38,35.57 JSSD1.57 ; UV1.AC26 118.82,140.72 v2(119.01,140.72) ; UV1.Y25 120.96,140.2 v2(121.41,140.65) 121.86,140.2 UV1.W25 ; JSSD1.33 31.38,33.31 31.44,33.24 31.44,33.22 31.82,32.84 v2(31.89,32.84) ; JFP1.1 221.02,30.99 221.18,31.15 v2(221.53,31.15) ; JHDD1.4 188.7,36.1 v2(188.12,36.69) ; v2(27.16,35.37) 27.16,35.21 26.87,34.93 JSSD1.51 ; JSSD1.45 28.38,35.15 v2(28.29,35.24) ; JDIMM1.106 69.95,83.74 69.63,84.06 v2(69.63,84.16) ; v2(189.48,36.71) 189.62,36.71 190.2,36.13 JHDD1.1 ; UV1.K11 129.31,128.82 v2(129.31,128.69) ; v2(116.88,131) 116.94,131.05 UV1.AE14 ; UV1.AB24 120.17,140.03 v2(120.17,140.85) ; UV1.U25 123.17,140.2 v2(123.61,140.64) 123.68,140.64 124.12,140.2 UV1.T25 ; UV1.Y32 121.38,144.64 v2(121.71,144.64) ; v2(124.63,142.41) 124.94,142.1 UV1.R27 ; 115.3,141.8 v2(114.95,141.44) ; 115.3,141.8 UV1.AG27 ; 115.3,141.8 115.3,141.83 UV1.AH28 ; v2(123.61,141.34) 123.55,141.4 123.55,141.59 UV1.U27 ; v2(45.69,98.48) 45.58,98.37 JESPI1.9 ; UV1.F16 132.14,133.13 v2(132.41,133.4) ; v2(32.52,32.85) 32.54,32.85 32.87,33.19 JSSD1.27 ; v2(187.49,36.69) 187.2,36.4 JHDD1.7 ; v2(118.16,127.77) UV1.AC9 ; v2(122.54,141.27) 122.27,141 UV1.W26 ; v2(76.36,122.93) 76.77,123.34 77.85,123.34 78.16,123.65 JWLAN1.13 ; v2(213.39,50.86) 213.3,50.95 JEDP1.20 ; JDIMM2.107 67.62,83.49 67.98,83.84 v2(67.98,84.16) ; JFP1.3 220.02,29.83 219.71,29.52 v2(219.55,29.52) 219.52,29.56 JFP1.4 ; v2(213.78,41.95) 213.5,41.95 213.5,41.95 213.1,41.95 213.09,41.95 JEDP1.38 ; v2(213.63,44.79) 213.47,44.95 JEDP1.32 ; 80.68,125.15 80.67,125.15 JWLAN1.19 ; v2(129.39,138.07) 129.39,138.05 UV1.K22 ; v2(213.39,43.58) 213.26,43.45 JEDP1.35
  BOTTOM w0.356: RV51.2 155.86,132.92 156.11,132.67 CV172.2 ; v2(137.5,117.92) 137.17,117.59 CZ24.2 ; UV2.3 108.1,120.06 107.98,119.94 107.48,119.94 v2(107.48,119.95) ; CV160.2 v2(164.85,139.03) CV153.2 ; CZ1.2 130.84,106.66 CZ3.2 ; CV151.2 155.23,149.59 RV55.2 ; CV157.2 v2(164.88,137.86) ; CZ2.2 v2(128.05,109.96) ; CV155.2 v2(164.85,140.14) ; CV181.2 v2(165.34,130.11) ; CC6.2 v2(110.45,61.27) ; CV158.2 v2(164.88,135.67)
  BOTTOM w0.381: EU5.1 221.49,35.18 v2(221.51,35.15) ; UV1.P25 125.63,140.2 v2(126.15,140.72) 126.67,140.2 UV1.N25 ; CV191.2 v2(165.63,119.69) ; v2(223.4,35.99) 223.23,35.81 EU6.1 ; CV164.2 164.94,118.3 v2(165.21,118.03) ; UV1.H20 130.07,136.87 130.07,136.91 v2(130.08,136.91) ; CV190.2 v2(165.63,120.71) ; v2(121.79,136.25) UV1.Y20 ; v2(118.22,133.43) 118.25,133.47 118.25,133.71 UV1.AC17 ; CV183.2 v2(165.64,126.86) ; ED2.1 v2(210.54,39.64) ; CU13.2 19.76,51.53 v2(19.97,51.75) ; CV182.2 v2(165.64,124.7) ; CV189.2 v2(165.63,121.72) ; UV1.V11 v2(122.78,129.44) ; v2(130.55,43.03) 130.7,43.03 131.17,42.56 131.17,42.43 131.56,42.05 CC79.1 131.79,42.18 131.79,43.51 131.91,43.64 RE22.2 ; v2(202.31,40.28) 202.73,40.69 PCB19.2 ; CV184.2 v2(165.64,127.94) ; U3.5 v2(177.44,63.73) ; UV1.P9 125.01,127.4 v2(124.86,127.25) ; CV188.2 v2(165.63,122.74)
  BOTTOM w0.4: v2(135.1,123.17) 135.09,123.17 UV1.A3
  BOTTOM w0.406: Q16.1 27.71,128.31 v2(27.47,128.07) ; Q16.4 30.53,129.61 v2(30.9,129.98) ; JESPI1.12 v2(42.95,99.87) ; v2(42.04,92.77) JESPI1.11
  BOTTOM w0.457: RC55.2 123.94,42.43 123.97,42.46 124.44,42.46 v2(124.48,42.49)
  BOTTOM w0.508: RI16.2 v2(14.89,108.26) ; v2(126.56,29.44) 128.05,27.95 JTP1.10 ; PCI120.2 157.96,70.8 v2(157.96,71.18) ; v2(206.41,35.8) 206.2,36.01 JIOB1.8 ; CS30.2 182.79,37.22 v2(182.79,38.22) ; RV163.2 RV4.2 v2(108.62,138.11) ; v2(157.96,76) 157.96,75.62 PCI126.2 ; v2(120.56,113.34) 119.97,113.93 CZ35.1 CZ36.1 ; UC3.4 129.23,33.59 129.23,32.99 v2(129.26,32.96) ; PRH09.2 167.05,44.46 v2(167.23,44.64) ; v2(156.69,71.18) 156.69,70.8 PCI125.2 ; JFAN1.5 v2(178.88,75) ; PCA118.2 v2(153.2,57.15) ; CV18.2 110.19,139.56 v2(110.59,139.95) ; CZ28.2 134.18,114.86 v2(134.4,114.86) ; JIOB1.10 v2(204.2,35.8) ; v2(29.63,38.67) 28.99,39.3 EU4.1 ; R40.2 91.78,35.75 v2(91.78,35.25) ; v2(156.63,78.42) 156.63,78.04 PCI129.2 ; v2(154.5,133.21) 154.79,132.92 RV51.2 ; v2(182.81,56.82) 183.18,56.45 PCZ02.2 ; v2(108.62,143.32) 109.33,144.03 CV17.2 ; PCG10.2 158.64,97.65 158.4,97.4 v2(158.13,97.4) 158.11,97.39 PHZ05.2 ; CC5.1 119.39,36.06 v2(119.72,35.74) ; PCI30.2 169.49,86.93 v2(169.83,86.93) ; RC63.2 v2(117.94,42.48) ; PR511.2 PC516.2 PR508.2 24.72,91.5 v2(24.55,91.32) ; v2(221.78,62.23) 221.24,62.76 JPWR1.1 ; v2(24.62,115.37) 24.98,115.37 25.1,115.5 RT9.2 ; YV1.4 106.66,142.88 v2(107.1,143.31) ; v2(203.36,51.11) PRB17.1 PRB16.2 ; JODD1.14 191.2,66.73 190.83,66.36 v2(190.83,65.98) 190.83,65.21 191.2,64.84 JODD1.13 ; v2(96.54,36.62) 96.54,36.22 C22.2 ; v2(129.71,117.13) 130.23,117.13 CZ27.2 ; v2(192.91,32.73) 192.16,31.98 JHDD1.13 ; JSPK1.5 v2(13.2,2.01) ; JSSD1.76 19.78,30.34 v2(19.59,30.16) ; JPWR1.6 226.84,66.4 226.33,65.89 225.61,65.89 v2(225.59,65.91) ; PRB28.1 199.3,41.84 199.04,41.59 v2(199.04,40.95) ; CV96.2 v2(150.94,117.33) ; v2(139.86,65.46) 139.48,65.84 CC19.2 141.14,66.1 CC71.2 ; PCB07.2 201.8,51.05 PCB71.2 v2(201.46,51.94) ; v2(119.34,28.09) 119.34,27.99 118.8,27.45 JTP1.9 113.42,27.45 113.14,27.16 C26.2 ; v2(123.72,117.34) 123.92,117.54 RV21.1 ; CT20.2 v2(27.21,113.65) ; v2(19.01,47.77) PR303.2 19.76,46.98 PR308.2 ; JKB1.32 84.43,30.92 84.93,31.43 v2(85.18,31.43) ; JODD1.25 196.95,65.8 v2(196.81,65.65) ; v2(89.62,121.91) 89.41,121.7 PHV01.2 ; v2(183.87,61.43) 183.65,61.43 183.55,61.33 C28.2 ; JEDP1.42 216.81,62.15 v2(217.46,62.8) ; PCI108.2 155.42,70.8 v2(155.42,71.18) ; RV134.2 156.3,134.32 v2(155.6,135.02) ; v2(208.14,48.19) 208.56,48.19 PCB10.2 ; RC119.2 v2(121.95,40.88) ; RC201.2 RC108.1 123.48,43.67 123.18,43.37 v2(123.18,43.02) ; JODD1.7 v2(188.2,66.12) JODD1.8 ; PCI123.2 157.96,78.04 v2(157.96,78.42) ; v2(180.25,74.23) 180.77,73.7 JFAN1.4 ; RC66.1 v2(110.22,58.61) ; v2(122.26,38.6) 121.69,39.16 RC116.1 ; v2(181.45,36.69) 181.97,36.69 182.41,36.25 CS29.2 ; v2(29.35,91.04) 28.25,92.15 28.09,92.15 27.34,92.9 PC2506.2 ; UU1.2 v2(19.97,51.75) ; CZ5.2 126.86,109.41 v2(127.42,109.96) ; CC4.2 118.04,37.81 v2(117.79,37.81) ; v2(209.2,35.7) JIOB1.5 ; v2(185.01,65.97) 184.59,65.55 183.2,65.55 JODD1.26 ; CV173.2 v2(163.04,132.33) ; PCW09.2 PRW02.2 v2(139.28,112.9) ; JSPK1.6 v2(16.71,2.01) ; JPWR1.5 218.64,66.84 219.05,67.24 v2(219.68,67.24) ; v2(165.63,123.62) 165.03,123.62 RV119.2 ; v2(141.26,49.79) 141.19,49.79 141.13,49.84 140.57,49.84 RC83.2 ; EU11.1 v2(12.23,125.15) ; v2(211.18,45.9) 210.85,46.24 PCB11.2 210.52,46.22 PCB12.2 ; CZ7.2 123.35,106.23 v2(122.84,106.74) 123.35,107.25 CZ6.2 ; v2(177.39,68.26) 177.6,68.47 JFAN1.6 ; v2(108.14,129.58) 108.14,129.05 108.02,128.94 RV88.1 ; PCH11.2 v2(166.09,42.73) ; PCZ23.2 v2(172.63,47.84) ; CZ33.1 CZ30.2 CZ32.1 119.67,106.36 120.18,105.85 v2(120.56,105.85) ; RV55.2 155.56,150.61 v2(155.53,150.64) ; v2(159.11,133.18) 158.85,132.92 RV121.2 ; PCI119.2 156.63,75.62 v2(156.63,76) ; v2(134.38,31.25) 134.96,31.25 136.05,32.34 136.05,33.02 ; v2(26.58,132.52) 27.09,132.01 RC158.2 ; PC6.2 95.67,149.73 v2(95.09,150.3) ; RC187.1 v2(113.57,32.49) ; v2(126.97,117.79) RV151.2 RV152.1 ; PC12.2 176.89,34.72 PBATT1.11 v2(176.11,33.21) ; PJPDC1.8 89.3,149.14 v2(89.57,149.41) ; CZ26.2 134.96,114.25 134.68,114.25 133.77,113.33 v2(133.77,113.22) ; JIOB1.18 195.03,33.75 194.02,32.73 v2(193.65,32.73) ; CL21.2 v2(27.38,71.19) ; v2(142.22,89.86) 142.27,89.81 RC141.1 RC143.1 RC142.1 ; PCZ34.2 v2(171.23,51.24) ; JEDP1.41 217.85,39.25 v2(218.03,39.43) ; v2(154.15,71.18) 154.15,70.8 PCI103.2 ; RV123.2 156.4,150.57 v2(156.43,150.6) ; PCB05.2 v2(198.28,46.1) ; v2(169.4,70.86) PCI08.2 PCI05.2 ; v2(151.93,114.98) 152.88,114.98 RV117.2 ; v2(132.37,105.09) CZ4.2 131.17,105.39 131.61,105.82 RC11.1 ; JIOB1.17 215.05,33.75 v2(214.37,34.43) ; CZ8.2 126.75,104.33 127.26,103.82 v2(127.26,103.81) ; v2(128.05,109.96) 128.32,110.23 v3(128.32,110.69) 128.44,110.82 130.54,110.82 131.15,110.21 CC76.2 ; v2(131.78,106.99) CZ3.2 ; v2(96.3,32.57) 96.74,32.57 97.25,32.06 JKBBL1.5 ; v2(100.67,36.69) 101.06,36.3 101.06,34.09 100.38,33.41 Q6.3 ; v2(207.28,50.95) 207.8,50.43 PCB09.2 PRB23.2 ; PCW11.2 144.31,112.36 PRW04.2 v2(145.78,112.36) ; v2(170.93,61.24) PCZ30.2 171.69,62 PRZ55.2 ; C21.2 15.83,131.88 v2(15.35,131.88) ; JODD1.1 v2(185.2,62.82) ; PCB04.2 v2(198.28,48.57) ; EU7.1 15.27,117.91 v2(15.53,117.66) ; CZ25.1 v2(138.34,115.95) ; RC137.1 RC138.1 142.91,84.15 v2(142.91,85.53) ; JFP1.9 v2(215.37,25.66) ; UZ5.9 134.41,116.91 v2(134.89,117.39) ; PRZ64.2 v2(170.34,52.31) ; JFP1.10 v2(221.22,27.47) ; RV38.2 148.53,115.36 v2(148.15,114.98) 148.1,115.03 148.09,115.03 147.87,115.25 147.87,115.26 147.64,115.49 CV97.2 ; PC5.2 v2(94.01,150.3) ; RV89.1 v2(111.46,128.33) ; v2(119.19,119.82) 119.19,118.96 119.55,118.6 RV83.2 ; CC74.2 v2(131.48,26.14) ; JIOB1.2 212.2,36.33 v2(211.68,35.81) ; JTP1.5 v2(121.05,31.68) ; PCA04.2 161.07,59.11 v2(161.45,59.49) ; JODD1.2 184.88,67.62 v2(184.24,67.62) ; PBATT1.12 151.79,34.6 v2(150.91,34.6) ; JKB1.31 v2(58.27,28.75) ; PCW10.2 141.69,111.44 PRW10.2 141.69,112.8 v2(141.6,112.89)
  vias: v2(1.63,126.87) v2(1.93,105.52) v2(3.42,88.67) v2(4.64,112.6) v2(4.74,130.5) v2(4.93,42.63) v2(5.06,133.67) v2(5.55,65.5) v2(5.8,132.33) v2(5.8,128.67) v2(5.77,114.56) v2(5.77,110.64) v2(5.89,41.2) v2(6.52,118.19) v2(6.89,124.43) v2(6.95,43.03) v2(6.95,39.37) v2(7.76,82.41) v2(7.9,132.33) v2(7.9,128.67) v2(8.03,114.56) v2(8.03,110.64) v2(8.96,130.5) v2(9.11,118.23) v2(9.05,43.03) v2(9.05,39.37) v2(9.18,125.8) v2(9.24,116.89) v2(9.16,112.6) v2(9.54,105.03) v2(9.7,36.43) v2(9.78,22.07) v2(10.11,41.2) v2(10.28,124.83) v2(10.65,63.71) v2(10.94,89.86) v2(10.93,1.86) v2(11.15,60.33) v2(11.65,45.97) v2(12.4,41.56) v2(12.4,40.8) v2(12.4,40.04) v2(12.4,38.92) v2(12.54,120.2) v2(12.68,133.67) v2(13.12,119.63) v2(13.85,43.54) v2(13.85,42.91) v2(13.85,42.32) v2(13.85,41.71) v2(13.93,30.09) v2(13.93,24.09) v2(14.44,43.57) v2(14.44,42.93) v2(14.44,42.31) v2(14.45,41.71) v2(14.43,22.93) v2(18.18,97.06) v2(18.18,95.26) v2(18.18,93.07) v2(18.18,91.27) v2(18.18,89.34) v2(18.42,0.43) v2(19.08,118.68) v2(19.21,120.58) v2(19.85,27.43) v2(19.85,26.79) v2(20.3,133.67) v2(20.48,27.43) v2(20.48,26.79) v2(20.61,60.64) v2(20.61,60) v2(20.74,90.99) v2(20.99,91.63) v2(21.18,60.32) v2(21.75,93.15) v2(21.87,89.83) v2(22.01,53.14) v2(22.01,52.38) v2(22.17,122.93) v2(22.26,94.42) v2(22.26,43.65) v2(22.51,96.71) v2(22.51,31.81) v2(22.58,95.56) v2(22.96,97.09) v2(23.02,55.43) v2(23.11,122.93) v2(23.08,83.38) v2(23.08,82.26) v2(23.08,81.14) v2(23.58,104.25) v2(23.72,54.86) v2(23.72,54.22) v2(23.72,53.59) v2(23.72,52.95) v2(24.18,105.9) v2(24.21,104.25) v2(24.2,83.38) v2(24.2,82.26) v2(24.2,81.14) v2(24.81,105.9) v2(24.8,104.25) v2(24.8,77.4) v2(25.31,83.38) v2(25.31,82.26) v2(25.31,81.14) v2(25.31,76.64) v2(25.45,105.9) v2(25.56,97.17) v2(26.04,0.43) v2(26.08,105.9) v2(26.69,76.89) v2(27.47,85.53) v2(27.72,78.23) v2(27.78,6.47) v2(27.92,133.67) v2(28.23,124.2) v2(28.44,96.55) v2(28.44,95.91) v2(28.44,95.28) v2(28.44,94.64) v2(28.44,94.01) v2(28.48,123.38) v2(28.61,58.86) v2(28.6,51.54) v2(28.69,117.98) v2(28.69,116.84) v2(28.92,84.76) v2(29.02,96.55) v2(29.02,95.91) v2(29.02,95.28) v2(29.02,94.64) v2(29.02,94.01) v2(29.04,51.11) v2(28.99,6.47) v2(29.49,37.01) v2(29.6,96.55) v2(29.6,95.91) v2(29.6,95.28) v2(29.6,94.64) v2(29.6,94.01) v2(29.75,117.98) v2(29.75,116.84) v2(29.88,49.84) v2(30.08,14.59) v2(30.08,13.01) v2(30.08,11.44) v2(30.16,96.75) v2(30.16,96.12) v2(30.16,95.48) v2(30.16,94.85) v2(30.16,94.21) v2(30.7,111.18) v2(30.7,110.55) v2(30.82,117.98) v2(30.82,116.84) v2(30.9,58.35) v2(31.34,111.18) v2(31.34,110.55) v2(31.4,49.53) v2(31.66,14.59) v2(31.66,13.01) v2(31.66,11.44) v2(31.78,38.67) v2(31.78,36.25) v2(31.78,4.69) v2(31.97,111.18) v2(31.97,110.55) v2(32.23,5.14) v2(32.42,36.25) v2(33.23,14.59) v2(33.23,13.01) v2(33.23,11.44) v2(33.44,40.44) v2(33.66,0.43) v2(34.01,5.01) v2(34.18,38.4) v2(34.51,5.65) v2(35.09,40.83) v2(35.54,133.67) v2(35.98,39.17) v2(36.22,28.81) v2(36.85,29.43) v2(36.85,28.19) v2(37.05,16.51) v2(37.05,15.92) v2(37.47,28.81) v2(37.88,39.17) v2(38.53,25.33) v2(38.52,24.7) v2(38.71,8.63) v2(38.9,58.03) v2(39.28,14.79) v2(39.28,14.16) v2(39.28,13.52) v2(39.28,12.89) v2(39.59,43.43) v2(39.72,23.31) v2(40.08,88.26) v2(40.31,23.31) v2(40.37,4.03) v2(40.77,19.26) v2(40.77,11.64) v2(40.89,23.31) v2(41.47,23.31) v2(41.56,33.33) v2(41.56,32.63) v2(41.93,137.82) v2(42.06,23.31) v2(42.17,29.93) v2(42.64,23.31) v2(42.78,29.93) v2(43.23,23.31) v2(43.29,129.9) v2(43.34,56.89) v2(43.34,56.13) v2(43.72,36.13) v2(44.04,112.14) v2(44.4,131.81) v2(44.39,127.99) v2(44.48,86.36) v2(44.7,24.53) v2(45.28,24.53) v2(45.37,112.2) v2(45.87,24.53) v2(46.45,24.53) v2(46.61,131.81) v2(46.6,127.99) v2(47.02,108.77) v2(47.02,108.14) v2(47.04,24.53) v2(47.45,22.93) v2(47.71,129.9) v2(48.34,102.67) v2(48.68,141.37) v2(48.92,32.56) v2(49.44,45.14) v2(49.5,32.56) v2(49.56,101.91) v2(50.07,46.45) v2(50.08,32.56) v2(50.67,32.56) v2(51.25,32.56) v2(53.01,44.24) v2(53.12,42.44) v2(55.07,22.93) v2(55.91,106.1) v2(56.3,141.37) v2(56.32,108.9) v2(56.75,103.46) v2(56.75,102.06) v2(56.75,100.66) v2(56.83,99.24) v2(56.84,98.24) v2(56.84,91.29) v2(56.82,88.12) v2(56.8,51.11) v2(56.89,94.59) v2(56.93,93.24) v2(56.92,89.74) v2(56.92,86.83) v2(56.92,83.85) v2(56.93,54.92) v2(56.85,50.48) v2(56.98,63.24) v2(56.98,62.24) v2(56.98,61.24) v2(56.98,59.24) v2(56.98,57.74) v2(56.98,49.74) v2(56.99,48.7) v2(56.96,46.36) v2(58.12,26.93) v2(59.52,52.74) v2(59.67,107.12) v2(59.9,26.55) v2(59.98,72.34) v2(60.05,69.06) v2(60.07,84.09) v2(60.35,91.17) v2(60.43,102.07) v2(60.37,57.97) v2(60.37,47.45) v2(60.55,74.78) v2(60.75,105.93) v2(60.81,108.89) v2(60.81,103.46) v2(60.81,100.73) v2(60.81,98.15) v2(60.81,95.48) v2(60.81,92.57) v2(60.81,89.27) v2(60.81,79.29) v2(60.81,66.8) v2(60.75,64.95) v2(60.75,61.64) v2(60.75,59.61) v2(60.75,56.63) v2(60.75,54.66) v2(60.75,50.88) v2(60.75,49.24) v2(60.75,46.19) v2(60.86,118.87) v2(61.32,80.56) v2(61.51,72.34) v2(61.59,84.09) v2(61.57,82.23) v2(61.55,76.8) v2(61.57,70.78) v2(61.57,69.06) v2(61.7,86.01) v2(61.9,107.26) v2(61.9,63.37) v2(61.9,52.25) v2(62.02,128.97) v2(61.95,96.75) v2(62,31.4) v2(62.33,108.89) v2(62.27,105.93) v2(62.33,103.46) v2(62.33,100.73) v2(62.33,98.15) v2(62.33,95.48) v2(62.33,92.57) v2(62.33,89.27) v2(62.33,79.29) v2(62.33,66.8) v2(62.28,64.95) v2(62.28,61.64) v2(62.28,59.61) v2(62.28,56.63) v2(62.28,54.66) v2(62.28,50.88) v2(62.28,49.24) v2(62.28,46.19) v2(62.33,30.92) v2(62.61,118.87) v2(62.71,102.07) v2(62.7,91.17) v2(62.66,57.97) v2(62.66,47.45) v2(62.69,22.93) v2(62.84,80.56) v2(62.84,74.78) v2(63.03,72.34) v2(63.12,84.09) v2(63.09,82.23) v2(63.09,79.29) v2(63.08,76.8) v2(63.09,70.78) v2(63.09,69.06) v2(63.22,86.01) v2(63.8,105.93) v2(63.8,64.95) v2(63.8,61.64) v2(63.8,59.61) v2(63.8,56.63) v2(63.8,54.66) v2(63.8,50.88) v2(63.8,49.24) v2(63.8,46.19) v2(63.92,141.37) v2(63.86,108.89) v2(63.86,103.46) v2(63.86,100.73) v2(63.86,98.15) v2(63.86,95.48) v2(63.86,92.57) v2(63.86,89.27) v2(63.86,66.8) v2(64.19,107.26) v2(64.24,96.75) v2(64.18,63.37) v2(64.18,52.25) v2(64.36,118.8) v2(64.36,80.56) v2(64.64,84.09) v2(64.62,79.29) v2(64.62,69.06) v2(64.68,128.46) v2(64.74,86.01) v2(64.78,125.3) v2(64.8,91.17) v2(66.58,32.25) v2(67.22,32.25) v2(67.74,95.19) v2(67.73,92.57) v2(67.75,87.54) v2(67.73,59.92) v2(67.68,56.81) v2(67.73,54.21) v2(67.73,52.75) v2(67.66,46.22) v2(67.8,103.16) v2(67.84,98.15) v2(67.8,96.75) v2(67.78,85.66) v2(67.84,49.02) v2(67.85,107.26) v2(67.91,105.93) v2(67.9,65.08) v2(67.96,89.27) v2(68.11,136.46) v2(68.11,110.42) v2(69,51.04) v2(69.25,110.42) v2(69.44,102.04) v2(69.38,49.02) v2(69.49,105.93) v2(69.46,103.17) v2(69.5,98.15) v2(69.5,87.54) v2(69.5,59.9) v2(69.59,95.48) v2(69.63,92.57) v2(69.63,58.11) v2(69.63,56.79) v2(69.67,89.27) v2(69.71,54.21) v2(69.73,51.04) v2(69.65,46.27) v2(70.31,22.93) v2(71.38,142.89) v2(72.31,63.77) v2(72.65,131.22) v2(72.65,129.7) v2(72.65,128.18) v2(72.71,84.16) v2(72.75,81.64) v2(72.75,79.95) v2(72.68,72.3) v2(72.75,69.06) v2(72.87,85.66) v2(73.05,91.28) v2(73.07,102.02) v2(73.07,58.14) v2(73.07,47.52) v2(73.2,51.01) v2(73.32,103.22) v2(73.35,61.77) v2(73.51,100.73) v2(73.51,95.48) v2(73.51,92.57) v2(73.51,89.27) v2(73.49,76.39) v2(73.45,64.95) v2(73.45,59.93) v2(73.45,56.82) v2(73.45,54.19) v2(73.45,49.02) v2(73.45,46.27) v2(73.59,105.93) v2(73.56,98.15) v2(73.57,74.02) v2(73.71,109.17) v2(74.18,131.22) v2(74.18,129.7) v2(74.18,128.18) v2(74.23,84.16) v2(74.21,72.3) v2(74.27,81.64) v2(74.27,79.95) v2(74.27,78.26) v2(74.27,69.06) v2(74.4,85.66) v2(74.6,63.65) v2(74.6,52.75) v2(74.67,107.23) v2(74.65,96.75) v2(74.84,103.22) v2(74.79,51.04) v2(74.87,61.77) v2(75.03,100.73) v2(75.03,95.48) v2(75.03,92.57) v2(75.03,89.27) v2(75.01,76.39) v2(74.98,64.95) v2(74.98,59.93) v2(74.98,56.82) v2(74.98,54.19) v2(74.98,49.02) v2(74.98,46.27) v2(75.11,105.93) v2(75.09,98.15) v2(75.23,109.17) v2(75.35,137.03) v2(75.34,91.28) v2(75.36,102.02) v2(75.36,47.52) v2(75.47,119.74) v2(75.47,74.02) v2(75.7,131.22) v2(75.7,129.7) v2(75.7,128.18) v2(75.73,72.3) v2(75.76,84.16) v2(75.79,81.64) v2(75.79,79.95) v2(75.79,78.26) v2(75.78,76.39) v2(75.79,70.67) v2(75.79,69.06) v2(75.79,66.89) v2(75.92,85.66) v2(76.11,137.98) v2(76.34,117.01) v2(76.31,51.04) v2(76.37,103.22) v2(76.4,61.77) v2(76.5,64.95) v2(76.5,59.93) v2(76.5,56.82) v2(76.5,54.19) v2(76.5,49.02) v2(76.5,46.27) v2(76.62,135.06) v2(76.64,105.93) v2(76.56,100.73) v2(76.61,98.15) v2(76.56,95.48) v2(76.56,92.57) v2(76.56,89.27) v2(76.76,109.17) v2(76.94,96.75) v2(76.88,63.65) v2(76.88,52.75) v2(76.95,107.23) v2(77.28,84.16) v2(77.3,76.39) v2(77.32,66.89) v2(77.45,85.66) v2(77.38,74.02) v2(77.63,120.9) v2(77.76,137.47) v2(77.93,22.93) v2(78.09,117.06) v2(79.16,117.09) v2(79.78,150.47) v2(80.43,109.17) v2(80.43,105.96) v2(80.39,92.57) v2(80.43,61.77) v2(80.43,58.14) v2(80.43,49.02) v2(80.47,103.19) v2(80.46,89.27) v2(80.54,84.16) v2(80.45,74.02) v2(80.53,54.2) v2(80.65,98.15) v2(80.57,95.48) v2(80.55,56.82) v2(80.55,52.75) v2(80.68,138.87) v2(80.68,138.17) v2(80.68,137.35) v2(80.68,136.58) v2(80.69,133.56) v2(80.74,127.88) v2(80.69,100.73) v2(81.03,74.02) v2(81.06,117.03) v2(81.44,142.43) v2(81.44,141.41) v2(81.44,140.39) v2(81.44,127.39) v2(81.62,74.02) v2(81.95,128.9) v2(82.03,127.39) v2(82.2,74.02) v2(82.65,133.35) v2(82.65,127.38) v2(82.75,69.06) v2(84.64,127.24) v2(84.64,126.65) v2(84.65,133.55) v2(84.65,132.79) v2(84.67,130.75) v2(84.67,129.99) v2(84.67,129.23) v2(85.28,130.75) v2(85.28,129.99) v2(85.28,129.23) v2(85.51,37.14) v2(85.51,35.62) v2(85.51,34.09) v2(85.55,22.93) v2(85.89,130.75) v2(85.89,129.99) v2(85.89,129.23) v2(86.5,130.75) v2(86.5,129.99) v2(86.5,129.23) v2(87.03,37.14) v2(87.03,35.62) v2(87.03,34.09) v2(87.11,130.75) v2(87.11,129.99) v2(87.11,129.23) v2(87.11,40.38) v2(87.71,130.75) v2(87.71,129.99) v2(87.71,129.23) v2(87.73,40.38) v2(88.07,32.01) v2(88.17,29.01) v2(88.32,130.75) v2(88.32,129.99) v2(88.32,129.23) v2(88.55,37.14) v2(88.55,35.62) v2(88.55,34.09) v2(88.93,130.75) v2(88.93,129.99) v2(88.93,129.23) v2(89.54,130.75) v2(89.54,129.99) v2(89.54,129.23) v2(90.15,130.75) v2(90.15,129.99) v2(90.15,129.23) v2(90.27,113.49) v2(90.76,130.75) v2(90.76,129.99) v2(90.76,129.23) v2(91.16,59.24) v2(91.37,130.75) v2(91.37,129.99) v2(91.37,129.23) v2(91.54,59.69) v2(91.77,153.97) v2(91.98,130.75) v2(91.98,129.99) v2(91.98,129.23) v2(92.03,113.49) v2(92.59,130.75) v2(92.59,129.99) v2(92.59,129.23) v2(93.2,130.75) v2(93.2,129.99) v2(93.17,22.93) v2(93.38,118.74) v2(93.63,117.16) v2(95.03,56.32) v2(97.7,84.35) v2(98.33,28.38) v2(99.09,84.35) v2(99.61,62.95) v2(100.03,63.36) v2(100.43,143.19) v2(100.43,142.55) v2(100.43,141.92) v2(100.36,45.27) v2(100.49,84.35) v2(100.79,22.93) v2(101.69,144.18) v2(101.89,116.58) v2(101.89,84.35) v2(102.52,116.58) v2(103.16,116.58) v2(103.41,144.71) v2(103.79,116.58) v2(103.85,58.86) v2(104.25,59.73) v2(104.3,60.58) v2(104.43,58.92) v2(105.31,84.38) v2(105.7,79.06) v2(105.71,63.3) v2(105.97,66.54) v2(106.14,86.19) v2(106.19,80.87) v2(106.26,72.84) v2(106.37,83.95) v2(106.71,112.96) v2(106.66,69.87) v2(107.12,147.66) v2(107.13,68.2) v2(107.16,82.57) v2(107.36,80.85) v2(107.54,75.67) v2(107.48,63.64) v2(107.83,87.99) v2(108.16,72.84) v2(108.35,23.88) v2(108.43,66.54) v2(108.51,91.91) v2(108.53,80.67) v2(108.49,77.09) v2(108.5,71.14) v2(108.6,153.97) v2(108.62,112.96) v2(108.56,89.3) v2(108.56,69.87) v2(108.73,84.26) v2(108.75,86.69) v2(108.76,64.9) v2(108.88,79.06) v2(108.98,82.55) v2(109.09,68.21) v2(109.22,148.14) v2(109.28,90.61) v2(109.38,93.22) v2(109.74,87.99) v2(110.13,82.22) v2(110.14,75.63) v2(110.07,72.84) v2(110.21,66.54) v2(110.41,91.91) v2(110.43,71.17) v2(110.46,89.3) v2(110.47,69.87) v2(110.65,149.46) v2(110.65,148.05) v2(110.76,64.86) v2(111.16,74.14) v2(111.29,93.22) v2(111.43,83.23) v2(112.62,139.89) v2(112.88,126.05) v2(114.52,139.89) v2(114.69,127.54) v2(115.46,148.7) v2(115.48,44.71) v2(115.97,23.88) v2(116.14,155.07) v2(116.96,97.88) v2(116.96,96.79) v2(117.2,148.84) v2(117.41,43.33) v2(117.92,83.52) v2(117.95,44.13) v2(118.14,101.4) v2(118.18,129.77) v2(118.27,99.64) v2(118.39,98.74) v2(118.39,96.84) v2(118.54,148.78) v2(119.03,112.33) v2(119.03,110.55) v2(119.24,76.23) v2(119.8,135.38) v2(119.79,132.48) v2(119.8,98.7) v2(120.03,96.23) v2(120.18,128.2) v2(120.44,148.05) v2(120.67,87.21) v2(120.87,110.49) v2(121.32,125.41) v2(121.28,98.13) v2(121.28,96.23) v2(121.75,134.3) v2(121.76,130.41) v2(121.77,78.51) v2(121.77,77.6) v2(121.77,76.69) v2(121.77,75.78) v2(122.7,98.38) v2(122.7,95.84) v2(122.93,131.52) v2(122.91,67.05) v2(122.97,65.02) v2(123.59,23.88) v2(123.74,136.36) v2(123.76,155.07) v2(123.8,153.05) v2(123.96,93.2) v2(124.05,67.05) v2(124.11,65.02) v2(124.34,97.28) v2(124.34,95.37) v2(124.3,84.39) v2(124.65,133.49) v2(124.61,131.4) v2(124.75,64.88) v2(124.75,62.43) v2(124.9,154.96) v2(124.91,151.13) v2(124.94,126.23) v2(125,73.34) v2(125,72.45) v2(125,71.56) v2(125,70.67) v2(125.19,67.05) v2(125.51,84.39) v2(125.68,136.39) v2(125.74,130.53) v2(126.02,64.88) v2(126.02,62.43) v2(126.34,67.05) v2(126.64,137.24) v2(126.6,136.36) v2(126.75,132.48) v2(126.65,130.49) v2(126.8,146.27) v2(127,82.14) v2(127.11,154.96) v2(127.12,151.13) v2(127.29,106.61) v2(127.29,64.89) v2(127.29,62.42) v2(127.43,146.27) v2(127.48,67.05) v2(127.58,82.14) v2(128.22,153.05) v2(128.53,62.42) v2(128.62,67.05) v2(128.56,64.89) v2(128.67,132.26) v2(129.46,134.74) v2(129.76,67.05) v2(131.21,23.88) v2(131.37,154.57) v2(133.93,146.99) v2(134.27,106.18) v2(134.55,105.65) v2(134.86,106.18) v2(135.04,27.11) v2(135.14,105.65) v2(135.44,106.18) v2(135.72,105.65) v2(136.03,106.18) v2(136.31,105.65) v2(136.31,96.2) v2(136.62,142.06) v2(136.76,132.52) v2(136.91,130.98) v2(137.42,127.14) v2(137.75,144.42) v2(138.15,96.01) v2(138.55,132.62) v2(138.6,127.12) v2(138.67,131.01) v2(138.85,61.02) v2(138.83,23.88) v2(138.97,155.07) v2(139.13,62.29) v2(139.25,124.91) v2(139.27,57.58) v2(139.44,27.1) v2(139.56,142.46) v2(140.04,55.96) v2(140.5,28.93) v2(140.5,25.27) v2(140.62,52.64) v2(140.75,56.95) v2(140.88,62.29) v2(141,143.43) v2(141,60.96) v2(141.83,69.53) v2(142.02,92.26) v2(142.02,91.63) v2(142.38,62.8) v2(142.6,28.93) v2(142.6,25.27) v2(143.08,69.53) v2(143.25,57.3) v2(143.42,97.72) v2(143.42,97.09) v2(143.42,96.45) v2(143.42,95.82) v2(143.66,27.1) v2(146.45,23.88) v2(146.59,155.07) v2(146.62,36.2) v2(147.1,51.11) v2(147.42,73.78) v2(147.74,74.86) v2(148.32,66.82) v2(148.5,83.82) v2(148.5,83.18) v2(148.5,82.55) v2(148.5,81.91) v2(148.5,71.5) v2(149.51,108.19) v2(149.69,50.41) v2(150.1,108.19) v2(150.28,50.41) v2(150.53,54.73) v2(150.53,52.89) v2(150.75,139.87) v2(150.68,108.19) v2(150.91,50.41) v2(151.44,139.9) v2(151.55,50.41) v2(151.67,125.74) v2(151.8,52.83) v2(151.93,117.45) v2(152.43,52.83) v2(152.5,89.34) v2(152.5,88.73) v2(152.5,88.13) v2(152.5,87.52) v2(152.56,61.53) v2(152.56,60.89) v2(152.56,60.26) v2(152.56,59.62) v2(152.88,108.2) v2(153.11,89.34) v2(153.11,88.73) v2(153.11,88.13) v2(153.11,87.52) v2(153.18,124.38) v2(153.3,126.04) v2(153.37,113.24) v2(153.37,112.66) v2(153.46,108.2) v2(153.7,103.82) v2(153.7,103.18) v2(153.7,102.55) v2(154.07,23.88) v2(154.21,155.07) v2(154.17,126.01) v2(154.47,103.82) v2(154.47,103.18) v2(154.47,102.55) v2(154.47,101.91) v2(155.23,124.38) v2(155.77,125.46) v2(156.22,148.14) v2(157.63,108.2) v2(157.63,107.62) v2(157.64,103.44) v2(157.64,102.67) v2(157.64,101.91) v2(157.71,36.81) v2(158.07,91.67) v2(158.21,108.2) v2(158.21,107.62) v2(158.54,94.03) v2(158.81,64.54) v2(158.92,92.89) v2(158.92,91.33) v2(159.29,48.32) v2(159.29,47.68) v2(159.29,47.05) v2(159.29,46.41) v2(159.29,45.78) v2(159.29,45.14) v2(159.93,48.32) v2(159.93,47.68) v2(159.93,47.05) v2(159.93,46.41) v2(159.93,45.78) v2(159.93,45.14) v2(160.21,92.89) v2(160.21,91.33) v2(160.44,63.88) v2(161.16,80.76) v2(161.16,80.13) v2(161.16,79.54) v2(161.16,78.91) v2(161.51,92.89) v2(161.51,91.33) v2(161.69,23.88) v2(161.81,154.57) v2(161.79,89.78) v2(161.85,89.18) v2(161.86,82.53) v2(161.86,81.94) v2(161.86,81.32) v2(161.86,80.74) v2(161.86,80.12) v2(161.86,79.53) v2(161.86,78.91) v2(162.06,92.03) v2(162.25,62.88) v2(162.27,90.59) v2(162.34,51.05) v2(162.35,89.99) v2(162.44,89.18) v2(162.43,60.81) v2(162.43,60.18) v2(162.43,59.54) v2(162.5,82.53) v2(162.5,81.94) v2(162.5,81.32) v2(162.5,80.74) v2(162.5,80.12) v2(162.5,79.53) v2(162.5,78.91) v2(162.72,65.24) v2(162.66,51.62) v2(162.82,90.39) v2(162.95,86.44) v2(162.95,85.14) v2(162.95,83.85) v2(163.02,89.18) v2(162.98,51.05) v2(163.12,92.12) v2(163.06,89.84) v2(163.08,82.53) v2(163.08,81.94) v2(163.08,81.32) v2(163.08,80.74) v2(163.08,80.12) v2(163.08,79.53) v2(163.13,78.91) v2(163.1,64.09) v2(163.1,62.53) v2(163.07,60.81) v2(163.07,60.18) v2(163.07,59.54) v2(163.29,87.29) v2(163.29,51.62) v2(163.51,90.39) v2(163.64,89.82) v2(163.62,89.19) v2(163.61,51.05) v2(163.7,92.12) v2(163.65,83.3) v2(163.67,82.53) v2(163.67,81.94) v2(163.67,81.32) v2(163.67,80.74) v2(163.67,80.12) v2(163.67,79.53) v2(163.7,60.81) v2(163.7,60.18) v2(163.7,59.54) v2(163.77,78.91) v2(163.93,51.62) v2(164.14,90.39) v2(164.23,89.81) v2(164.21,89.19) v2(164.25,51.05) v2(164.28,92.12) v2(164.34,60.81) v2(164.34,60.18) v2(164.34,59.54) v2(164.39,64.09) v2(164.39,62.53) v2(164.51,86.44) v2(164.51,85.14) v2(164.51,83.85) v2(164.56,51.62) v2(164.72,90.39) v2(164.82,89.82) v2(164.87,92.12) v2(164.88,70.8) v2(164.88,51.05) v2(164.88,37.08) v2(164.97,60.81) v2(164.97,60.18) v2(164.97,59.54) v2(165.2,51.62) v2(165.32,90.75) v2(165.35,90.16) v2(165.52,70.8) v2(165.61,60.81) v2(165.61,60.18) v2(165.61,59.54) v2(165.65,86.82) v2(165.69,64.09) v2(165.69,62.53) v2(165.67,32.62) v2(166.24,63.24) v2(166.21,61.46) v2(166.24,60.81) v2(166.24,60.18) v2(166.24,59.54) v2(166.34,68.64) v2(166.85,61.46) v2(166.88,60.81) v2(166.88,60.18) v2(166.88,59.54) v2(166.91,32.62) v2(166.98,68.64) v2(166.98,62.73) v2(166.98,62.1) v2(167.29,38.67) v2(167.29,38.03) v2(167.48,61.46) v2(167.51,60.81) v2(167.51,60.18) v2(167.51,59.54) v2(167.61,62.1) v2(167.76,102.7) v2(167.77,102.09) v2(167.77,101.45) v2(167.77,100.82) v2(167.93,38.67) v2(167.93,38.03) v2(168.07,53.1) v2(168.06,52.07) v2(168.56,38.67) v2(168.56,38.03) v2(168.74,27.16) v2(169.07,152.24) v2(169.07,144.62) v2(169.2,38.67) v2(169.2,38.03) v2(169.32,137) v2(169.31,23.88) v2(169.8,129.4) v2(169.83,83.85) v2(169.83,83.23) v2(169.83,38.67) v2(169.83,38.03) v2(170.28,121.79) v2(170.47,38.67) v2(170.47,38.03) v2(170.6,43.49) v2(170.6,42.86) v2(170.6,42.22) v2(170.77,114.19) v2(170.82,106.57) v2(171.1,38.67) v2(171.1,38.03) v2(171.48,43.49) v2(171.48,42.86) v2(171.48,42.22) v2(171.73,99) v2(172.22,91.4) v2(173.01,32.82) v2(173.41,57.92) v2(173.41,55.9) v2(173.41,53.88) v2(173.54,33.18) v2(173.62,32.57) v2(173.64,30.03) v2(174.08,84.01) v2(175.43,57.92) v2(175.43,55.9) v2(175.43,53.88) v2(175.37,30.3) v2(176.06,32.51) v2(176.93,23.88) v2(177.45,57.92) v2(177.45,55.9) v2(177.45,53.88) v2(178.4,77.74) v2(180.68,36.69) v2(182.35,29.23) v2(184.37,55.68) v2(184.57,73.26) v2(184.63,55.11) v2(185.84,60.83) v2(187.61,60.83) v2(188.88,60.83) v2(189.97,29.28) v2(190.66,60.83) v2(191.04,69.24) v2(194.53,41.91) v2(194.53,41.27) v2(194.53,40.64) v2(195.17,41.91) v2(195.17,41.27) v2(195.17,40.64) v2(195.8,41.91) v2(195.8,41.27) v2(195.8,40.64) v2(196.44,42.54) v2(196.44,41.91) v2(196.44,41.27) v2(196.88,46.67) v2(196.88,46.03) v2(196.88,45.4) v2(197.59,29.28) v2(197.77,61.3) v2(197.77,60.71) v2(197.77,60.13) v2(198.59,68.19) v2(202.32,55.9) v2(202.32,53.89) v2(202.9,54.89) v2(203.49,55.9) v2(203.49,53.89) v2(203.54,45.52) v2(204.63,46.62) v2(204.63,45.52) v2(204.63,44.43) v2(205.21,29.28) v2(205.34,63.85) v2(205.72,45.52) v2(206.18,67.47) v2(206.4,65.68) v2(206.4,62.02) v2(208.21,33.08) v2(208.44,41.58) v2(208.43,38.79) v2(208.5,65.68) v2(208.5,62.02) v2(209.46,32.49) v2(209.56,63.85) v2(210.43,38.63) v2(212.83,29.25) v2(215.9,54.87) v2(215.93,52.64) v2(216.77,35.98) v2(216.95,50.73) v2(217.33,54.67) v2(217.78,48.97) v2(218.24,23.88) v2(221.34,68.97) v2(221.52,46.29) v2(222.67,67.9) v2(224.11,67.14) v2(224.82,65.34) v2(224.97,42.69) v2(224.97,35.07) v2(224.97,27.45) v2(225.1,53.55) v2(225.33,51.75) v2(225.66,59.83) v2(225.86,50.26) v2(226.07,53.22) v2(226.37,58.15) v2(226.53,61.37) v2(226.59,65.16) v2(227.97,65.2) v2(227.97,57.58) v3(13.48,121.62) v3(22.98,56.52) v3(26.08,81.19) v3(26.77,97.95) v3(36.5,34.34) v3(45.91,25.36) v3(70.94,45.78) v3(78,146.57) v3(82.14,131.69) v3(103.68,84.44) v3(120.82,77.54) v3(140.92,105.61) v3(154.96,105.39) v3(157.21,106.65) v3(159.38,92.06) v3(160.66,45.54) v3(162.49,78.2) v3(165.48,51.07) v3(165.45,50.97) v3(165.91,90.11) v3(167.22,90.32) v3(168.45,60.61) v3(168.64,60.47) v3(170.96,41.04) v3(174.23,54.71) v3(179.59,36.51) v3(195.86,43.25) v3(196.48,40.67) v3(202.64,51.34) v3(202.98,56.19)
