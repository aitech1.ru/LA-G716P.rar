# Allegro board LA-G716P r0.1.brd (continued)
## Routing (per net, layer and track width the routed paths; a pad name or vN(x,y) marks a point on that pad's centre or on a via; arc(x,y) is an arc through that point) (continued)
CLK_PCIE_N2: length 185.9
  TOP w0.112: UL1.16 26.71,83.66 26.79,83.58 27.23,83.58 27.81,84.15 30.67,84.15 31.81,85.3 33.45,85.3 33.86,85.71 33.86,86.69 35.08,87.91 35.88,87.91 36.21,88.23 36.21,89.63 36.39,89.81 36.39,90.96 37.15,91.72 37.15,103.66 44.64,111.15 44.64,111.51 v2(44.46,111.69)
  IN1 w0.119: v2(107.98,112.94) 107.98,111.37 108.18,111.18 122.13,111.18 127.78,105.53 129.45,105.53 130.91,104.07 130.91,102.52 135.4,98.03 136.75,97.49 138.95,97.49 140.03,96.41 140.03,72.28 142.64,69.67 142.64,69.17 v2(142.82,68.98)
  IN3 w0.135: v2(107.98,112.94) 107.96,112.97 107.96,113.47 107.58,113.85 103.07,113.85 102.29,113.07 86.65,113.07 86.15,113.58 81.77,113.58 81.3,114.05 78.14,114.05 77.01,115.18 47.4,115.18 45.78,113.56 44.94,113.56 44.46,113.08 v2(44.46,111.69)
  BOTTOM w0.076: 139.18,67.05 139.16,67.05 139.14,67.08 138.91,67.08 138.36,66.52 137.31,66.52 137.19,66.39 136.3,66.39 136.09,66.6 135.98,66.6 135.91,66.53 135.91,66.44 135.83,66.36 135.6,66.36 135.55,66.42 135.55,66.62 UC1.BD3
  BOTTOM w0.112: v2(142.82,68.98) 142.64,68.8 142.64,67.6 142.08,67.05 139.18,67.05
CLK_PCIE_N4: length 182.1
  IN1 w0.119: v2(26.55,35.48) 26.64,35.48 26.74,35.37 26.74,35.09 26.64,34.98 26.31,34.98 26.19,34.86 26.19,34.61 27.31,33.48 29.47,33.48 30.53,32.43 35.54,32.43 36.02,31.94 45.97,31.94 47.22,33.19 54.28,33.19 54.75,32.72 56.22,32.72 65,23.95 100.32,23.95 101.27,24.9 128.09,24.9 128.1,24.9 128.51,24.9 131.04,27.43 133.24,27.43 137.07,31.27 145.29,31.27 147.85,33.83 147.85,50.27 149.82,52.24 149.82,54.92 150.48,55.58 150.48,62.68 145.94,67.22 139.88,67.22 138.55,68.55 138.27,68.55 138.16,68.44 138.16,68.11 138.07,68.03 137.82,68.03 137.7,68.15 v2(137.7,68.18)
  BOTTOM w0.076: UC1.BA1 136.36,68.52 136.28,68.45 136.28,68.34 136.39,68.23 136.76,68.23 136.84,68.31 136.84,68.44 136.93,68.52 137.08,68.52 137.21,68.39 137.49,68.39 v2(137.7,68.18)
  BOTTOM w0.112: v2(26.55,35.48) 26.37,35.29 26.37,35.02 26.27,34.92 26.27,34.71 26.38,34.61 JSSD1.53
CLK_PCIE_P1: length 152.3
  IN1 w0.119: v2(141.55,69.01) 141.37,69.19 141.37,69.67 139.31,71.72 139.31,96.05 138.59,96.77 136.62,96.77 134.44,97.53 126.87,105.09 125.39,105.09 122.57,107.91 121.03,107.91 118.93,110.01 108.33,110.01 106.3,112.04 96.27,112.04 92.82,115.49 89.08,115.49 87.06,117.5 82.87,117.5 78.43,121.95 71.84,121.95 70.68,120.79 68.74,120.79 67.38,119.43 67.38,118.25 66.88,117.75 63.75,117.75 63.63,117.88 63.63,118.68 v2(63.78,118.83)
  BOTTOM w0.076: UC1.BC2 136.11,67.21 136.36,66.95 136.84,66.95 136.93,67.04 138.14,67.04 139.04,67.94 139.18,67.94
  BOTTOM w0.112: v2(63.78,118.83) 63.6,119.01 63.6,126.49 64.27,127.17 67.46,127.17 67.84,127.54 72.97,127.54 73.53,128.11 73.53,131.54 74.28,132.29 77.96,132.29 78.1,132.15 JWLAN1.47 ; v2(141.55,69.01) 141.37,68.83 141.37,68.18 141.13,67.94 139.18,67.94
CLK_PCIE_P2: length 185.9
  TOP w0.102: UL1.15 26.68,83.26
  TOP w0.112: v2(45.05,111.69) 44.87,111.51 44.87,111.06 37.37,103.56 37.37,91.63 36.61,90.86 36.61,89.72 36.43,89.54 36.43,88.14 35.98,87.69 35.17,87.69 34.08,86.6 34.08,85.61 33.54,85.08 31.9,85.08 30.76,83.93 27.9,83.93 27.33,83.36 26.78,83.36 26.68,83.26
  IN1 w0.119: v2(142.23,68.98) 142.42,69.17 142.42,69.58 139.81,72.19 139.81,96.32 138.86,97.27 136.71,97.27 135.28,97.84 130.69,102.43 130.69,103.98 129.36,105.31 127.69,105.31 122.04,110.96 108.09,110.96 107.77,111.28 107.77,112.34 107.68,112.43 107.37,112.43 107.27,112.53 107.27,112.81 v2(107.4,112.94)
  IN3 w0.135: v2(107.4,112.94) 107.56,113.1 107.56,113.12 107.72,113.27 107.72,113.37 107.48,113.61 103.17,113.61 102.39,112.83 86.55,112.83 86.05,113.33 81.67,113.33 81.2,113.81 78.04,113.81 76.91,114.93 47.5,114.93 45.88,113.32 45.04,113.32 44.7,112.98 44.7,112.05 44.89,111.87 44.89,111.85 v2(45.05,111.69)
  BOTTOM w0.076: UC1.BC3 135.51,66.95 135.73,66.95 135.91,66.77 136.16,66.77 136.37,66.56 137.12,66.56 137.25,66.68 138.29,66.68 138.85,67.24 139.14,67.24 139.16,67.27 139.18,67.27
  BOTTOM w0.112: v2(142.23,68.98) 142.42,68.8 142.42,67.7 141.99,67.27 139.18,67.27
CLK_PCIE_P4: length 182.1
  IN1 w0.119: v2(137.7,68.76) 138.64,68.76 139.97,67.44 146.03,67.44 150.7,62.77 150.7,55.49 150.04,54.83 150.04,52.15 148.07,50.18 148.07,33.74 145.38,31.05 137.17,31.05 133.33,27.21 131.13,27.21 128.6,24.68 128,24.68 101.36,24.68 100.41,23.73 64.9,23.73 56.13,32.5 54.66,32.5 54.19,32.97 47.31,32.97 46.06,31.72 35.93,31.72 35.45,32.21 30.44,32.21 29.38,33.27 27.22,33.27 25.97,34.52 v2(25.97,35.48)
  BOTTOM w0.076: v2(137.7,68.76) 137.49,68.56 137.28,68.56 137.14,68.69 136.81,68.69 136.79,68.69 136.7,68.78 136.08,68.78 135.9,68.59 UC1.BA2
  BOTTOM w0.112: JSSD1.55 25.87,34.64 26.05,34.81 26.05,35.01 26.15,35.11 26.15,35.29 v2(25.97,35.48)
CLK_PEG_N0: length 114
  IN3 w0.135: v2(113.7,144.84) 113.57,144.71 113.55,144.71 113.36,144.52 113.36,144.03 112.91,143.58 112.48,143.58 112.1,143.2 112.1,141.04 111.25,140.2 111.25,132.06 113.52,129.79 113.52,125.46 115.6,123.38 126.27,123.38 133.32,116.33 134.16,116.33 137,113.48 137,110.22 143.72,103.5 143.72,99.39 144.98,98.13 144.98,89.26 147.93,86.32 147.93,81.53 146.59,80.19 146.59,75.46 145.83,74.7 145.83,72.91 147.34,71.39 147.61,71.39 147.79,71.57 147.8,71.57 v2(147.96,71.73)
  BOTTOM w0.102: UV1.AK32 113.64,144.2 113.5,144.34 113.5,144.78 113.51,144.78
  BOTTOM w0.112: v2(113.7,144.84) 113.56,144.84 113.51,144.78 ; v2(147.96,71.73) 147.61,71.73 147.53,71.65 147.53,71.48 147.42,71.37 145.39,71.37 144.51,70.49 141.26,70.49 140.14,69.37 137.42,69.37 137.33,69.29 135.81,69.29 135.75,69.34 135.7,69.34 135.57,69.48 135.57,69.64 135.67,69.73 135.81,69.73 UC1.AW2
CLK_PEG_P0: length 114
  IN3 w0.135: v2(147.96,71.15) 147.24,71.15 145.59,72.81 145.59,74.8 146.35,75.56 146.35,80.29 147.68,81.63 147.68,86.22 144.74,89.16 144.74,98.03 143.48,99.29 143.48,103.4 136.76,110.12 136.76,113.38 134.06,116.09 133.22,116.09 126.17,123.13 115.5,123.13 113.28,125.36 113.28,129.69 111.01,131.96 111.01,140.3 111.85,141.14 111.85,143.3 112.38,143.82 112.81,143.82 113.11,144.13 v2(113.11,144.84)
  BOTTOM w0.102: 113.23,144.78 113.29,144.73 113.29,144.69 113.29,144.69 113.29,144.25 113.3,144.25 113.3,143.84 UV1.AK30
  BOTTOM w0.112: v2(113.11,144.84) 113.18,144.84 113.23,144.78 ; UC1.AY3 137.42,69.09 137.5,69.17 139.07,69.17 139.09,69.15 140.23,69.15 141.35,70.27 144.61,70.27 145.48,71.15 v2(147.96,71.15)
CLK_SMB: length 3.2
  TOP w0.112: PR42.1 160.94,40.65 v1(160.94,41.55) 161.18,41.55 v2(161.46,41.26)
  BOTTOM w0.112: v2(161.46,41.26) 161.46,41.09 161.01,40.64 PBATT1.7
CLK_TP_SIO: length 153.3
  TOP w0.112: UE1.78 44.55,82.6 44.51,82.56 44.51,82.2 44.62,82.09 v2(44.75,82.09) ; R35.2 124.62,29.09 124.62,29.31 v2(124.83,29.53) 124.83,29.59 124.95,29.7 125.21,29.7 v4(126.38,28.53) 126.54,28.37 127.26,28.37 C25.1
  IN3 w0.135: v2(45.1,35.67) 44.9,35.87 44.61,35.87 44.29,36.19 44.29,36.19 44.29,36.37 41.63,39.03 41.63,45.78 40.67,46.73 40.67,53.91 41.82,55.05 41.82,56.56 43.66,58.4 43.66,60.33 41.58,62.41 40.94,62.41 39.17,64.17 39.17,65.33 38.79,65.71 38.28,65.71 37.96,66.04 37.96,66.8 39.81,68.66 39.81,72.34 43,75.53 43,81.99 43.6,82.6 44.12,82.6 44.62,82.09 v2(44.75,82.09)
  BOTTOM w0.112: v2(45.1,35.67) 45.96,35.67 47.08,34.54 53.62,34.54 57.44,30.73 57.44,26.3 58.12,25.62 62.76,25.62 63.92,24.46 98.97,24.46 99.92,25.41 121.33,25.41 124.62,28.7 124.62,29.31 v2(124.83,29.53) 124.83,29.58 125.05,29.8 JTP1.1
CLKREQ_CNV#: length 193.7
  TOP w0.112: v2(118.67,51.61) 118.67,51.21 RC73.2
  IN2 w0.124: v2(55.59,124.19) 52.87,124.19 43.69,115 43.69,113.36 42.9,112.57 42.9,105.79 48.83,99.85 48.83,93.24 47.9,92.31 47.9,87.86 46.33,86.29 46.33,81.28 45.88,80.83 45.88,78.61 47.16,77.33 47.16,71.43 47.48,71.1 47.48,68.94 51.15,65.27 51.15,58.1 52.8,56.45 52.8,48.51 54.9,46.41 54.9,43.3 56.49,41.71 58.77,41.71 61.26,39.22 76,39.22 76.6,38.62 78.13,38.62 80.57,41.06 81.65,41.06 82.32,41.73 90.27,41.73 90.89,42.35 93.38,42.35 94.14,43.11 107.22,43.11 112.4,48.29 113.32,48.29 114.14,49.11 117.12,49.11 117.96,49.95 117.96,50.9 v2(118.67,51.61)
  BOTTOM w0.076: UC1.CH29 v2(118.67,51.61)
  BOTTOM w0.112: JWLAN1.14 69.33,123.9 67.56,122.13 67.56,117.95 67.09,117.48 v1(63.69,117.48) 63.19,117.98 58.52,117.98 55.59,120.91 v2(55.59,124.19)
CLKREQ_PCIE#1: length 200
  TOP w0.112: RC81.2 72.17,137.16 v2(72.93,137.16) 73.52,137.16 RW8.1
  IN1 w0.119: v2(72.93,137.16) 72.68,137.16 71.35,138.49 66.89,138.49 61.38,132.99 61.38,131.11 57.92,127.65 57.92,126.8 55.98,124.87 55.98,123.66 49.5,117.18 49.5,115.44 47.71,113.64 47.71,105.55 v2(48.17,105.09)
  IN3 w0.135: v2(117.31,54.37) 115.6,52.65 112.88,52.65 111.1,50.88 111.1,49.1 110.32,48.32 110.32,47.62 109.56,46.86 109.56,46.51 106.54,43.49 106.52,43.49 106.48,43.46 93.79,43.46 93.46,43.79 88.57,43.79 86.25,41.47 83.83,41.47 77.41,35.06 72.27,35.06 71.42,35.9 60.78,35.9 59.07,37.61 58.3,37.61 57.15,38.76 55.12,38.76 53.63,40.25 52.52,40.25 48.93,43.84 48.93,46.35 49.82,47.24 49.82,57.12 53.32,60.62 53.32,63.92 53.34,63.94 53.34,68.57 52.73,69.18 52.73,72.33 52.06,73 52.06,75.45 51.55,75.96 51.55,81.76 54.75,84.97 54.75,94.58 52.04,97.29 52.04,101.21 v2(48.17,105.09)
  BOTTOM w0.102: UC1.CE32 v2(117.31,54.37)
CLKREQ_PCIE#1_R: length 7.3
  TOP w0.112: RW8.2 v2(73.57,135.64)
  BOTTOM w0.112: v2(73.57,135.64) 73.87,135.64 75.87,133.65 JWLAN1.53
CLKREQ_PCIE#2: length 149.1
  TOP w0.112: RL5.1 30.8,80.64 30.81,80.63 RC85.2 31.8,80.63 31.91,80.74 31.91,81.83 31.58,82.16 31.58,82.91 32.29,83.62 32.29,84.18 32.69,84.58 34.64,84.58 35.72,83.5 v2(36.86,83.5)
  IN3 w0.135: v2(52.2,62.64) 51.69,62.64 50.9,61.84 50.9,61.08 49.12,59.3 49.12,47.43 48.29,46.6 48.29,41.77 52.34,37.72 57.08,37.72 58.29,36.51 59.06,36.51 61.22,34.35 70.78,34.35 71.31,33.83 77.65,33.83 84.02,40.19 85.58,40.19 85.96,39.81 88.43,39.81 90.6,41.98 106.13,41.98 110.34,46.19 110.34,46.53 111.13,47.32 111.13,48.02 111.89,48.78 111.89,50.55 113.21,51.87 117.05,51.87 v2(118.59,53.41)
  BOTTOM w0.112: v2(36.86,83.5) 44.1,83.5 45.8,81.8 45.8,79.3 50.83,74.26 50.83,68.77 52.2,67.4 v2(52.2,62.64)
  BOTTOM w0.127: UC1.CF30 118.59,53.36 v2(118.59,53.41)
CLKREQ_PCIE#2_R: length 4.2
  TOP w0.112: RL5.2 29.46,81.02 28.36,81.02 27.32,82.06 UL1.12
CLKREQ_PCIE#4: length 123.9
  TOP w0.112: v2(30.13,29.71) 29.61,29.19 RC88.2
  IN1 w0.119: v2(30.13,29.71) 30.07,29.71 25.01,34.78 25.01,35.5 26.18,36.67 30.92,41.42 47.44,41.42 48.88,39.98 52.31,39.98 v2(52.8,39.49)
  IN3 w0.135: v2(117.97,53.45) 117.97,53.44 116.65,52.13 113.1,52.13 111.63,50.66 111.63,48.88 110.84,48.1 110.84,47.41 110.08,46.64 110.08,46.3 106.38,42.6 88.12,42.6 86.47,40.95 84.4,40.95 77.93,34.48 71.39,34.48 71,34.87 61.07,34.87 59.05,36.89 58.28,36.89 57.14,38.03 53.63,38.03 52.8,38.86 v2(52.8,39.49)
  BOTTOM w0.089: v2(117.97,53.45) UC1.CE30
  BOTTOM w0.112: v2(30.13,29.71) 29.56,29.14 27.34,29.14 26.63,28.43 JSSD1.52
CLKREQ_PEG#0: length 246.9
  TOP w0.112: v2(100.94,116.58) v1(101.8,115.72) 102.18,115.34 v2(125.68,115.34)
  IN1 w0.119: v2(51.71,119.99) 49.06,117.33 49.06,115.63 47.46,114.03 47.46,105.16 v2(48.17,104.45)
  IN3 w0.135: v2(117.26,53.46) 116.18,52.39 112.99,52.39 111.37,50.77 111.37,48.99 110.58,48.21 110.58,47.51 109.82,46.75 109.82,46.4 106.27,42.86 88.01,42.86 86.36,41.21 83.94,41.21 77.52,34.79 72.16,34.79 71.31,35.64 60.67,35.64 59.04,37.27 58.27,37.27 57.13,38.41 55.09,38.41 53.56,39.94 52.47,39.94 48.67,43.74 48.67,46.46 48.68,46.47 48.68,46.54 49.44,47.3 49.44,57.11 52.6,60.27 52.6,63.07 51.8,63.86 51.8,74.98 51.29,75.5 51.29,81.87 54.16,84.74 54.16,94.34 51.36,97.14 51.36,101.26 v2(48.17,104.45) ; v2(51.71,119.99) 52.61,120.88 58.26,120.88 59.12,120.02 67.29,120.02 67.62,119.69 71.34,119.69 72.13,118.91 85.85,118.91 88.53,116.22 100.58,116.22 v2(100.94,116.58)
  BOTTOM w0.102: v2(117.26,53.46) 117.26,53.33 UC1.CF32
  BOTTOM w0.112: RV153.1 RC78.2 125.88,117.17 125.88,115.54 v2(125.68,115.34)
CLKREQ_PEG#0_R: length 7.4
  BOTTOM w0.102: 126.84,122.19 126.84,122.45 126.91,122.51 126.91,125.63 UV1.N7
  BOTTOM w0.112: RV153.2 RV152.2 126.27,119.58 v1(126.27,120.54) 126.27,120.84 126.84,121.41 126.84,122.19
CMP_STRAP0: length 1.8
  TOP w0.112: RE94.1 34.56,73.41 UE1.118
CMP_VIN0: length 13.5
  TOP w0.112: UE1.20 44.95,68.55 44.62,68.88 v2(44.62,69.13) ; v2(48.12,63.89) 48.12,63.62 48.48,63.25 v1(49.28,63.25) 49.9,62.63 50.41,62.63 51.3,63.52 RE34.1 51.3,64.54 RE38.1
  IN1 w0.119: v2(48.12,63.89) 48.12,63.89 48.12,65.2 44.62,68.7 v2(44.62,69.13)
CMP_VOUT0: length 61.5
  TOP w0.112: v2(40.58,78.78) 40.58,79.09 40.98,79.49 40.98,81.88 41.75,82.65 UE1.85 ; RE36.2 51.29,65.46 RE38.2 52.31,64.45 52.31,63.45 51.79,62.93 51.79,62.26 51.2,61.67 48.97,61.67 v2(48.57,62.07)
  IN1 w0.119: v2(48.57,62.07) 48.57,62.01 48.45,61.89 43.93,61.89 42.54,63.28 41.34,63.28 39.66,61.6 38.91,61.6 36.1,64.4 36.1,66.14 37.25,67.28 37.25,70.48 38.9,72.13 v2(40.55,72.13)
  IN2 w0.124: v2(40.55,72.13) 40.76,72.34 40.76,78.6 v2(40.58,78.78)
  IN3 w0.135: v2(28.56,83.14) 29.26,83.14 30.07,82.34 30.07,80.83 30.75,80.15 39.57,80.15 40.56,79.17 40.56,78.8 v2(40.58,78.78)
  BOTTOM w0.112: PR507.1 27.43,83.05 v1(28.05,83.05) 28.47,83.05 v2(28.56,83.14)
CMSRC_CHG: length 30.2
  TOP w0.127: v2(193.09,56.97) v1(193.09,56.22)
  TOP w0.508: PRB08.2 v2(193.09,56.97)
  IN2 w0.508: v2(204.38,42.53) 203.83,41.98 198.59,41.98 197.14,43.43 194.33,43.43 190.47,47.29 190.47,55.49 191.94,56.97 v2(193.09,56.97)
  BOTTOM w0.203: PUB01.5 204.43,42.58 v2(204.38,42.53)
CNV_BRI_CRX_DTX: length 200.1
  TOP w0.112: RC121.2 120.88,45.15 120.88,45.89 121.33,46.33 121.33,46.43 122.02,47.13 122.02,48.08 v1(122.87,48.93) 123.92,49.97 v2(123.92,50.64) ; RW3.2 61.79,126.04 61.64,126.2 60.8,126.2 v2(60.65,126.04)
  IN1 w0.119: v2(60.65,126.04) 60.66,126.03 60.66,125.72 51.35,116.42 51.35,115.22 49.13,113 49.13,103.64 48.8,103.31 48.8,102.55 v2(48.29,102.04)
  IN3 w0.135: v2(123.92,50.64) 123.91,50.64 123.73,50.46 123.73,49.33 122.22,47.82 120.38,47.82 120.32,47.76 115.88,47.76 114.85,46.74 114.08,46.74 113.68,46.34 113.68,45.38 113.4,45.1 111.82,45.1 106.68,39.96 106.43,39.7 103.43,39.7 102.58,38.85 91.41,38.85 91.04,38.85 89.56,37.36 89.56,33.14 88.98,32.57 85.51,32.57 84.24,31.3 82.2,31.3 81.78,31.72 78.99,31.72 78.35,32.36 70.8,32.36 70.34,32.82 60.52,32.82 59.35,33.99 58.73,33.99 56.35,36.38 50.58,36.38 46.52,40.44 46.52,47.68 47.79,48.95 47.79,59.95 49.56,61.73 49.56,63.18 50.23,63.84 50.23,73.04 48.71,74.57 48.71,77.31 49.64,78.24 49.64,80.12 49.17,80.59 49.17,81.99 50.15,82.98 50.53,82.98 52.84,85.29 52.84,93.79 50.05,96.59 50.05,99.02 48.42,100.64 48.42,101.91 v2(48.29,102.04)
  BOTTOM w0.076: v2(123.92,50.64) 123.97,50.59 UC1.CK20
CNV_BRI_CRX_DTX_R: length 7.7
  TOP w0.112: RW3.1 v2(64.92,126.04)
  BOTTOM w0.112: JWLAN1.22 65.06,125.9 v2(64.92,126.04)
CNV_BRI_CTX_DRX: length 24.8
  TOP w0.112: v2(123.93,51.22) 123.79,51.22 RC202.2 ; RW7.2 107.11,41.46 v1(109.95,44.3) 111.18,45.52 v2(113.04,45.52)
  IN3 w0.135: v2(123.93,51.22) 123.87,51.22 123.22,50.58 123.22,49.63 121.86,48.26 119.93,48.26 119.87,48.2 114.28,48.2 113.24,47.16 113.24,45.72 v2(113.04,45.52)
  BOTTOM w0.076: UC1.CJ20 123.94,51.24 v2(123.93,51.22)
CNV_BRI_CTX_DRX_R: length 182.4
  TOP w0.112: v2(104.4,39.28) 104.75,39.63 v1(104.75,39.7) 104.75,40.97 RW7.1
  IN1 w0.119: v2(47.91,103.32) 48.71,104.12 48.71,113.17 50.92,115.39 50.92,116.59 57.4,123.07 57.4,124.27 59.34,126.21 59.34,127.06 v2(61.88,129.6)
  IN3 w0.135: v2(104.4,39.28) 103.53,38.41 91.23,38.41 90,37.18 90,32.96 88.43,31.39 87.4,31.39 86.35,30.34 77.45,30.34 76.28,31.51 71.03,31.51 70.73,31.81 67.41,31.81 67.11,31.51 65.1,31.51 64.3,32.32 60.41,32.32 59.17,33.56 58.55,33.56 56.17,35.94 50.39,35.94 45.82,40.51 45.82,47.62 47.34,49.14 47.34,60.13 49.12,61.9 49.12,63.37 49.79,64.04 49.79,72.86 47.86,74.79 47.86,77.08 49.2,78.42 49.2,79.94 48.73,80.41 48.73,82.6 51.66,85.53 51.66,94.35 49.61,96.41 49.61,98.57 47.84,100.33 47.84,103.25 v2(47.91,103.32)
  BOTTOM w0.112: v2(61.88,129.6) 67.22,129.6 67.37,129.76 70.52,129.76 70.87,129.4 JWLAN1.36
CNV_CRX_DTX_N0: length 172.9
  IN1 w0.119: v2(117.95,46.46) 117.27,46.46 115.46,48.27 111.95,48.27 108.69,45.01 108.34,45.01 108.08,45.27 107.91,45.27 107.74,45.1 107.74,44.93 108,44.67 108,44.32 106.92,43.25 93.79,43.25 93.27,42.73 90.46,42.73 90.08,43.11 81.57,43.11 81.04,42.58 79,42.58 78.54,42.12 76.36,42.12 74.99,43.49 74.17,43.49 70.01,47.66 70.01,48.94 65.33,53.62 60.01,53.62 59.51,54.13 56.45,54.13 55.66,54.92 55.66,81.72 55.03,82.35 55.03,84.56 55.27,84.81 55.58,84.81 55.7,84.93 55.7,85.28 55.58,85.4 55.27,85.4 55.03,85.65 55.03,86.94 55.62,87.53 55.62,102.89 55.06,103.44 55.06,106.32 55.68,106.94 55.68,109.57 59.34,113.23 68.46,113.23 69.81,114.58 70.16,114.58 71.1,113.64 71.27,113.64 71.44,113.81 71.44,113.98 70.5,114.92 70.5,115.27 70.8,115.57 71.15,115.57 72.15,114.56 72.32,114.56 72.49,114.74 72.49,114.9 71.49,115.91 71.49,116.26 72.98,117.75 74.54,117.75 74.85,117.45 75.34,117.45 75.75,117.04 v2(75.75,117.04)
  BOTTOM w0.076: UC1.CR30 118.32,47.71 118.22,47.61 118.22,47.34 118.27,47.29 118.4,47.29 118.41,47.28 118.41,47.06 118.32,46.97 118.32,46.83 v2(117.95,46.46)
  BOTTOM w0.112: JWLAN1.15 78.25,124.15 78.14,124.26 78.14,124.32 78.03,124.43 77.63,124.43 77.09,124.97 76.49,124.97 75.97,124.46 75.97,122.77 76.08,122.66 76.08,119.34 75.39,118.64 75.39,117.4 v2(75.75,117.04)
CNV_CRX_DTX_N1: length 173
  IN1 w0.119: v2(117.95,44.71) 117.74,44.93 117.04,44.93 116.79,45.17 116.79,46.03 115.19,47.63 112.22,47.63 107.19,42.61 94.05,42.61 93.45,42 90.17,42 89.79,42.39 81.79,42.39 81.34,41.94 79.32,41.94 78.86,41.48 77.17,41.48 76.66,40.96 74.77,40.96 73.54,42.2 73.54,43.22 68.77,47.99 68.77,49.06 66.36,51.47 59.82,51.47 58.26,53.02 56.04,53.02 54.77,54.29 54.77,68.58 53.92,69.44 53.92,78 54.27,78.35 54.27,87.1 54.97,87.8 54.97,102.62 54.42,103.18 54.42,106.75 55.04,107.37 55.04,109.83 59.18,113.98 68.3,113.98 72.72,118.4 77.13,118.4 77.5,118.02 v2(77.5,117.04)
  BOTTOM w0.076: UC1.CM30 118.58,49.63 118.58,49.01 118.69,48.9 118.69,48.64 118.66,48.51 118.66,48.28 118.74,48.14 118.74,46.63 118.53,46.41 118.53,45.6 118.68,45.45 118.68,44.92 118.47,44.71 v2(117.95,44.71)
  BOTTOM w0.112: v2(77.5,117.04) 77.5,117.42 77.39,117.53 77.25,117.53 77.14,117.65 77.14,117.97 76.72,118.39 76.72,122.15 77.34,122.77 78.04,122.77 78.17,122.65 JWLAN1.9
CNV_CRX_DTX_P0: length 172.9
  IN1 w0.119: v2(75.17,117.04) 75.35,116.86 75.35,116.69 75.17,116.51 75,116.51 74.68,116.82 74.68,117.31 74.45,117.54 73.07,117.54 71.7,116.17 71.7,116 72.71,114.99 72.71,114.64 72.41,114.35 72.06,114.35 71.06,115.35 70.89,115.35 70.72,115.18 70.72,115.01 71.66,114.07 71.66,113.72 71.36,113.42 71.01,113.42 70.07,114.37 69.9,114.37 68.55,113.01 59.43,113.01 55.9,109.48 55.9,106.85 55.28,106.23 55.28,103.53 55.83,102.98 55.83,87.44 55.24,86.85 55.24,85.74 55.36,85.62 55.67,85.62 55.91,85.37 55.91,84.83 55.67,84.59 55.36,84.59 55.24,84.47 55.24,82.45 55.88,81.81 55.88,55.01 56.54,54.35 59.6,54.35 60.11,53.84 65.42,53.84 70.23,49.03 70.23,47.75 74.27,43.71 75.08,43.71 76.45,42.34 78.45,42.34 78.91,42.8 80.95,42.8 81.48,43.33 90.17,43.33 90.55,42.95 93.18,42.95 93.7,43.47 106.83,43.47 107.78,44.41 107.78,44.58 107.52,44.84 107.52,45.19 107.82,45.49 108.17,45.49 108.43,45.23 108.6,45.23 111.86,48.49 115.55,48.49 117.36,46.68 117.51,46.68 117.57,46.74 117.57,47.03 117.69,47.14 117.86,47.14 v2(117.95,47.05)
  BOTTOM w0.076: UC1.CP30 118.07,48.13 118.05,47.97 118.05,47.15 v2(117.95,47.05)
  BOTTOM w0.112: JWLAN1.17 77.72,124.65 77.18,125.19 76.4,125.19 75.75,124.55 75.75,122.68 75.86,122.57 75.86,119.43 75.17,118.74 v2(75.17,117.04)
CNV_CRX_DTX_P1: length 173
  IN1 w0.119: v2(117.95,45.3) 117.83,45.42 117.63,45.42 117.51,45.3 117.51,45.23 117.42,45.14 117.13,45.14 117.01,45.26 117.01,46.12 115.28,47.85 112.13,47.85 107.1,42.82 93.96,42.82 93.36,42.22 90.26,42.22 89.88,42.6 81.69,42.6 81.25,42.16 79.23,42.16 78.77,41.7 77.08,41.7 76.57,41.18 74.86,41.18 73.76,42.29 73.76,43.31 68.99,48.08 68.99,49.15 66.46,51.68 59.91,51.68 58.35,53.24 56.13,53.24 54.99,54.38 54.99,68.67 54.14,69.53 54.14,77.91 54.49,78.26 54.49,87.01 55.19,87.71 55.19,102.71 54.64,103.27 54.64,106.66 55.25,107.27 55.25,109.74 59.27,113.76 68.39,113.76 72.81,118.18 77.04,118.18 77.28,117.93 77.28,117.7 77.17,117.58 76.97,117.58 76.89,117.66 76.73,117.66 76.59,117.53 76.59,117.36 v2(76.92,117.04)
  BOTTOM w0.076: UC1.CN30 118.32,49.36 118.24,49.44 118.09,49.44 118.02,49.36 118.02,49.13 118.19,48.95 118.4,48.95 118.52,48.83 118.52,48.65 118.5,48.53 118.5,48.24 118.57,48.1 118.57,46.7 118.36,46.48 118.36,45.53 118.51,45.38 118.51,44.98 118.41,44.88 118.29,44.88 118.2,44.97 118.2,45.19 118.09,45.3 v2(117.95,45.3)
  BOTTOM w0.112: JWLAN1.11 78.23,123.15 78.08,122.99 77.25,122.99 76.5,122.24 76.5,118.3 76.92,117.88 v2(76.92,117.04)
CNV_CTX_DRX_N0: length 191.5
  IN1 w0.119: v2(75.78,137.45) 75.78,136.56 74.12,134.91 70.09,134.91 69.28,135.72 67.57,135.72 63.82,131.98 63.82,130.5 63.31,129.98 63.31,125.1 54.62,116.41 54.62,115.28 51.05,111.71 51.05,87.05 50.87,86.87 50.87,83.33 50.46,82.92 50.46,53.84 56.52,47.78 58.1,47.78 59.09,46.79 65,46.79 65.74,46.06 65.74,43.99 68.74,40.99 70.79,40.99 73.5,38.29 74.87,38.29 75.38,37.78 79.21,37.78 80.8,39.37 82.78,39.37 82.97,39.56 84.9,39.56 85.38,39.07 89.92,39.07 90.42,38.58 93.84,38.58 95.3,40.03 99.88,40.03 101.34,38.58 107,38.58 111.65,43.22 114.42,43.22 115.49,42.16 v2(117.41,42.16)
  BOTTOM w0.076: 116.41,43.5 116.41,43.52 116.44,43.55 116.44,45.83 116.94,46.33 116.94,47.23 117.2,47.97 117.2,48.9 117.13,48.98 116.82,48.98 116.75,49.06 116.75,49.33 116.82,49.41 116.94,49.41 117.01,49.33 UC1.CN32
  BOTTOM w0.112: JWLAN1.65 77.96,136.65 77.9,136.58 76.02,136.58 75.78,136.82 v2(75.78,137.45) ; v2(117.41,42.16) 117.15,42.16 117.14,42.16 116.84,42.16 116.41,42.6 116.41,43.5
CNV_CTX_DRX_N1: length 192.1
  IN1 w0.119: v2(77.78,134.76) 77.82,134.73 77.82,134.52 77.67,134.38 77.46,134.38 77.26,134.58 77.09,134.58 75.57,133.06 67.04,133.06 65.55,131.58 65.55,125.22 56.45,116.11 56.45,114.64 52.57,110.76 52.57,96.15 52.69,96.03 53.38,96.03 53.63,95.78 53.63,95.36 53.38,95.11 52.69,95.11 52.57,94.99 52.57,94.76 52.69,94.64 53.38,94.64 53.63,94.39 53.63,93.97 53.38,93.72 52.69,93.72 52.57,93.6 52.57,93.36 52.69,93.24 53.38,93.24 53.63,93 53.63,92.58 53.38,92.33 52.69,92.33 52.57,92.21 52.57,91.97 52.69,91.85 53.38,91.85 53.63,91.61 53.63,91.19 53.38,90.94 52.69,90.94 52.57,90.82 52.57,90.58 52.69,90.46 53.38,90.46 53.63,90.21 53.63,89.79 53.38,89.55 52.69,89.55 52.57,89.43 52.57,86.01 52.99,85.59 52.99,82.93 51.97,81.91 51.97,75.38 52.08,75.26 52.6,75.26 52.85,75.01 52.85,74.47 52.6,74.23 52.08,74.23 51.97,74.11 51.97,73.75 52.08,73.63 52.6,73.63 52.85,73.38 52.85,72.84 52.6,72.59 52.08,72.59 51.97,72.48 51.97,72.12 52.08,72 52.6,72 52.85,71.75 52.85,71.21 52.6,70.96 52.08,70.96 51.97,70.84 51.97,70.49 52.08,70.37 52.6,70.37 52.85,70.12 52.85,69.58 52.6,69.33 52.08,69.33 51.97,69.21 51.97,64.01 52.85,63.12 52.85,54.43 55.41,51.87 57.28,51.87 59.03,50.13 59.03,49.46 59.66,48.82 66.38,48.82 67.25,47.95 67.25,45.69 67.98,44.95 69.95,44.95 71.43,43.47 71.43,42.48 74.12,39.79 75.49,39.79 76,39.28 78.37,39.28 79.96,40.87 81.99,40.87 82.33,41.21 89.29,41.21 89.59,40.91 90.63,40.91 91.22,40.32 93.45,40.32 94.67,41.54 107.63,41.54 111,44.91 113.39,44.91 114.18,45.7 115.26,45.7 v2(115.44,45.88)
  BOTTOM w0.076: v2(115.44,45.88) 115.44,45.73 115.36,45.64 115.06,45.64 114.97,45.73 114.97,46.19 115.07,46.29 115.73,46.29 116.24,46.79 116.24,47.47 116.36,47.81 116.47,48.09 116.47,48.23 UC1.CP33
  BOTTOM w0.112: JWLAN1.59 78.38,135.15 78.1,135.43 77.98,135.43 77.78,135.23 v2(77.78,134.76)
CNV_CTX_DRX_P0: length 191.6
  IN1 w0.119: v2(117.41,42.74) 117.41,42.81 117.29,42.93 117.1,42.93 116.98,42.81 116.98,42.5 116.86,42.38 115.58,42.38 114.51,43.44 111.56,43.44 106.91,38.79 101.43,38.79 99.97,40.25 95.21,40.25 93.75,38.79 90.51,38.79 90.01,39.29 85.47,39.29 84.99,39.77 82.87,39.77 82.69,39.59 80.71,39.59 79.12,38 75.47,38 74.96,38.51 73.59,38.51 70.88,41.21 70.68,41.21 70.47,41.21 68.83,41.21 65.96,44.08 65.96,46.15 65.09,47.01 59.18,47.01 58.19,48 56.61,48 50.68,53.93 50.68,82.83 51.09,83.24 51.09,86.78 51.27,86.96 51.27,111.62 54.84,115.19 54.84,116.32 63.53,125.01 63.53,129.89 64.04,130.41 64.04,131.89 67.66,135.5 69.19,135.5 70,134.69 74.22,134.69 76,136.47 76,137.08 76.19,137.28 76.19,137.29 76.2,137.29 v2(76.36,137.45)
  BOTTOM w0.076: UC1.CM32 117.27,49.73 117.27,49.07 117.37,48.97 117.37,48.83 117.37,47.9 117.35,47.87 117.22,47.54 117.1,47.21 117.1,46.26 116.6,45.76 116.6,43.48 116.61,43.48 116.61,43.47
  BOTTOM w0.112: v2(76.36,137.45) 76.36,137.42 76,137.06 76,136.92 76.11,136.8 77.75,136.8 78.1,137.15 JWLAN1.67 ; v2(117.41,42.74) 117.24,42.57 117.24,42.57 117.05,42.38 116.9,42.38 116.61,42.68 116.61,43.47
CNV_CTX_DRX_P1: length 192.1
  IN1 w0.119: v2(115.44,45.3) 115.26,45.48 114.27,45.48 113.48,44.69 111.1,44.69 107.72,41.32 94.76,41.32 93.54,40.1 91.13,40.1 90.54,40.69 89.5,40.69 89.2,40.99 82.42,40.99 82.08,40.65 80.05,40.65 78.46,39.06 75.91,39.06 75.4,39.57 74.03,39.57 71.21,42.39 71.21,43.38 69.86,44.73 67.89,44.73 67.03,45.6 67.03,47.86 66.28,48.6 59.57,48.6 58.81,49.37 58.81,50.04 57.19,51.66 55.32,51.66 52.63,54.34 52.63,63.03 51.75,63.92 51.75,69.3 51.99,69.55 52.51,69.55 52.63,69.67 52.63,70.03 52.51,70.15 51.99,70.15 51.75,70.4 51.75,70.94 51.99,71.18 52.51,71.18 52.63,71.3 52.63,71.66 52.51,71.78 51.99,71.78 51.75,72.03 51.75,72.57 51.99,72.81 52.51,72.81 52.63,72.93 52.63,73.29 52.51,73.41 51.99,73.41 51.75,73.66 51.75,74.2 51.99,74.44 52.51,74.44 52.63,74.56 52.63,74.92 52.51,75.04 51.99,75.04 51.75,75.29 51.75,82 52.77,83.03 52.77,85.49 52.35,85.92 52.35,89.52 52.6,89.76 53.29,89.76 53.41,89.88 53.41,90.12 53.29,90.24 52.6,90.24 52.35,90.49 52.35,90.91 52.6,91.16 53.29,91.16 53.41,91.28 53.41,91.51 53.29,91.63 52.6,91.63 52.35,91.88 52.35,92.3 52.6,92.55 53.29,92.55 53.41,92.67 53.41,92.91 53.29,93.03 52.6,93.03 52.35,93.27 52.35,93.69 52.6,93.94 53.29,93.94 53.41,94.06 53.41,94.3 53.29,94.42 52.6,94.42 52.35,94.67 52.35,95.09 52.6,95.33 53.29,95.33 53.41,95.45 53.41,95.69 53.29,95.81 52.6,95.81 52.35,96.06 52.35,110.85 56.23,114.73 56.23,116.2 65.33,125.31 65.33,131.67 66.95,133.28 75.48,133.28 v2(77.37,135.17)
  BOTTOM w0.076: v2(115.44,45.3) 115.86,45.71 115.86,46.18 116.4,46.73 116.4,47.44 116.63,48.06 116.63,48.21 116.64,48.22 116.64,48.5 116.41,48.73 UC1.CN33
  BOTTOM w0.112: JWLAN1.61 77.89,135.65 77.42,135.17 v2(77.37,135.17)
CNV_RF_RESET#: length 190
  TOP w0.112: v2(116.62,50.63) 116.62,50.65 RC74.2
  IN2 w0.124: v2(116.62,50.63) 116.62,50.63 116.62,49.57 116.38,49.33 114.05,49.33 113.23,48.51 112.12,48.51 107.07,43.47 94.12,43.47 93.27,42.62 90.64,42.62 89.97,41.96 82.23,41.96 81.55,41.28 80.47,41.28 78.04,38.85 76.7,38.85 76.1,39.45 61.43,39.45 58.93,41.95 56.74,41.95 55.19,43.49 55.19,46.62 53.07,48.74 53.07,56.75 51.5,58.33 51.5,65.42 49.56,67.35 49.56,75.62 46.28,78.9 46.28,80.61 46.86,81.19 46.86,86.32 48.12,87.59 48.12,92.22 49.06,93.15 49.06,100.02 43.35,105.73 43.35,112.7 44.1,113.46 44.1,115.1 52.53,123.53 v2(54.65,123.53)
  BOTTOM w0.102: v2(116.62,50.63) 116.62,50.63 116.62,50.6 116.7,50.64 116.93,51.13 UC1.CJ32
  BOTTOM w0.112: v2(54.65,123.53) 54.65,120.2 57.95,116.9 v1(60.84,116.9) 61.16,116.58 66.94,116.58 68.41,118.05 68.41,121.57 69.32,122.48 70.32,122.48 70.74,122.9 JWLAN1.10
CNV_RGI_CRX_DTX: length 202.5
  TOP w0.112: v2(124.99,51.59) 124.78,51.59 124.41,51.22 v1(124.41,50.68) 124.41,49.91 122.32,47.83 122.32,46.84 122.11,46.63 122.11,45.43 121.95,45.27 RC122.2 ; v2(61.88,128.4) 62.64,128.4 RW6.2
  IN1 w0.119: v2(61.88,128.4) 61.8,128.4 61.08,127.68 61.08,125.55 51.77,116.24 51.77,115.04 49.56,112.82 49.56,103.46 49.23,103.14 49.23,102.37 v2(48.88,102.02)
  IN3 w0.135: v2(124.99,51.59) 124.91,51.66 123.69,51.66 122.78,50.76 122.78,49.81 121.68,48.7 119.75,48.7 119.69,48.64 114.1,48.64 112.8,47.34 112.8,46.4 111.99,45.59 111.69,45.59 106.24,40.14 103.76,40.14 103.58,40.32 94.42,40.32 93.51,39.41 93.49,39.41 93.37,39.29 91.59,39.29 90.86,39.29 89.12,37.55 89.12,33.77 88.36,33.01 85.32,33.01 84.05,31.74 82.39,31.74 81.94,32.19 79.26,32.19 78.65,32.8 70.99,32.8 70.39,33.4 60.57,33.4 59.53,34.43 59.12,34.43 56.73,36.83 50.77,36.83 46.96,40.64 46.96,47.49 48.23,48.76 48.23,59.69 50.01,61.46 50.01,62.23 50.67,62.89 50.67,74.69 49.65,75.71 49.65,76.82 50.08,77.24 50.08,80.3 49.61,80.77 49.61,81.81 50.33,82.54 50.71,82.54 53.28,85.11 53.28,93.97 50.48,96.77 50.48,99.2 48.86,100.83 48.86,102.01 v2(48.88,102.02)
  BOTTOM w0.076: v2(124.99,51.59) 125.12,51.81 UC1.CH19
CNV_RGI_CRX_DTX_R: length 8.1
  TOP w0.112: RW6.1 64.04,128.71 64.42,129.09 v2(64.89,129.09)
  BOTTOM w0.112: JWLAN1.34 70.18,128.9 69.8,129.28 68.46,129.28 68.11,128.93 65.04,128.93 v2(64.89,129.09)
CNV_RGI_CTX_DRX: length 34.9
  TOP w0.112: v2(125.86,52.22) 125.39,51.75 125.39,50.19 125.1,49.9 124.79,49.9 123.1,48.2 123.1,47.06 122.53,46.49 122.53,45.03 RC162.2 RC108.2 ; v2(111.54,46.03) 111.1,46.03 v1(107.77,42.71) 107.41,42.35 RW5.2
  IN3 w0.135: v2(125.86,52.22) 125.74,52.1 123.51,52.1 122.34,50.93 122.34,50.22 121.25,49.14 119.56,49.14 119.51,49.08 113.92,49.08 112.36,47.52 112.36,47.16 112.36,47.16 112.36,46.83 111.56,46.03 v2(111.54,46.03)
  BOTTOM w0.102: v2(125.86,52.22) 125.83,52.26 125.73,52.26 UC1.CG19
CNV_RGI_CTX_DRX_R: length 174.8
  TOP w0.112: v2(61.82,127.82) 62.14,127.5 63.29,127.5 RW4.1 64.23,127.3 64.23,127.36 v2(64.67,127.8) ; v2(103.99,40.58) 104.23,40.82 v1(104.23,41.12) 104.23,41.34 RW5.1
  IN1 w0.119: v2(61.82,127.82) 61.5,127.51 61.5,125.35 52.2,116.04 52.2,114.86 49.98,112.65 49.98,101.74 49.52,101.28 v2(49.44,101.28)
  IN3 w0.135: v2(103.99,40.58) 103.94,40.58 103.76,40.76 94.24,40.76 93.33,39.85 93.31,39.85 93.19,39.73 90.54,39.73 87.79,36.98 87.79,33.97 87.27,33.45 83.36,33.45 82.92,33.88 79.77,33.88 79.12,33.24 71.17,33.24 70.57,33.84 61.11,33.84 58.89,36.06 58.12,36.06 56.91,37.27 52.06,37.27 49.58,39.75 49.58,39.75 47.41,41.93 47.41,47.3 48.68,48.57 48.68,59.49 50.45,61.27 50.45,62.03 50.96,62.54 50.96,62.56 51.11,62.7 51.11,74.87 50.96,75.02 50.52,75.46 50.52,81.72 53.72,84.93 53.72,94.16 50.92,96.95 50.92,99.38 49.74,100.57 49.74,100.98 v2(49.44,101.28)
  BOTTOM w0.112: JWLAN1.32 70.09,128.4 70.01,128.48 69.63,128.86 68.8,128.86 68.45,128.52 66.77,128.52 66.13,127.88 64.75,127.88 v2(64.67,127.8)
CNV_WT_RCOMP: length 8.2
  TOP w0.254: v2(115.48,44.13) 115.6,44.13 v1(116.54,45.07) 116.82,45.35 RC60.2
  BOTTOM w0.254: UC1.CP32 116.94,48.02 UC1.CR32 116.87,47.96 116.68,47.43 116.68,46.48 116.18,45.97 116.18,44.57 115.73,44.13 v2(115.48,44.13)
COMP_1A_CPU: length 3.6
  BOTTOM w0.203: PUZ01.26 173.63,59.33 v1(172.75,60.21) 172.61,60.35 PCZ30.1
  BOTTOM w0.254: PCZ30.1 172.61,62.08 PCZ31.1
COMP_1B_CPU: length 5.5
  TOP w0.112: PCZ03.1 180.44,56.85 181.03,57.44 181.98,57.44 v1(182.34,57.8)
  TOP w0.254: PCZ03.1 PCZ01.1 180.1,55.51 v2(179.76,55.51)
  BOTTOM w0.203: v2(179.76,55.51) 179.58,55.7 PUZ01.43
COMP_2PH_CPU: length 4.8
  TOP w0.112: v2(176.69,51.62) 176.45,51.62 175.61,52.46 v1(175.61,52.71)
  TOP w0.254: PCZ16.2 177.4,51.06 PCZ15.2 176.83,51.62 v2(176.69,51.62)
  BOTTOM w0.203: PUZ01.4 176.43,51.89 v2(176.69,51.62)
COMP_CHG: length 3.2
  BOTTOM w0.203: PUB01.28 207.56,45.72 208.06,46.22 PCB12.1 PRB30.1
CPU_C10_GATE#: length 60.2
  TOP w0.112: UC9.2 98.62,51.62 98.9,51.91 98.9,52.23 98.36,52.76 94.98,52.76 94.44,52.22 93.11,52.22 92.55,51.67 v3(92.55,48.15) 92.55,47.27 v2(92.71,47.11)
  IN2 w0.124: v2(120.19,46.74) 119.8,47.12 119.8,47.49 119.54,47.75 117.74,47.75 116.68,46.69 115.34,46.69 113.61,44.96 111.12,44.96 107.84,41.68 94.54,41.68 93.92,41.06 92.19,41.06 v2(91.98,40.85)
  BOTTOM w0.076: UC1.CN27 120.16,48.96 120.16,48.96 119.93,48.41 119.93,48.21 119.99,48.06 120.01,48.05 120.01,47.79 119.84,47.62 119.84,47.09 v2(120.19,46.74)
  BOTTOM w0.112: v2(92.71,47.11) 92.74,47.15 93.8,47.15 94.13,47.48 95.76,47.48 96.22,47.02 96.34,46.89 96.34,44.14 94.86,42.66 93.79,42.66 v2(91.98,40.85)
CPU_DP1_CTRL_CLK: length 214.6
  TOP w0.089: v2(132.15,54.14) 132.18,54.17 132.87,54.17 133.28,53.77 134.5,53.77 134.85,54.12 135.42,54.12 135.44,54.15 135.54,54.15
  TOP w0.112: 135.54,54.15 139.69,54.15 140.01,54.47 142.6,54.47 143.42,53.65 144.1,53.65 RC7.2
  IN1 w0.089: 130.43,49.46 130.43,49.48 130.4,49.51 130.4,49.68 130.97,50.25 130.97,53.13 131.3,53.46 131.56,53.46 131.86,53.76 131.86,53.85 v2(132.15,54.14)
  IN1 w0.119: 130.43,49.46 130.43,49.3 129.22,48.09 128.84,48.09 128.56,47.81 128.56,46.79 127.72,45.96 127.72,44.72 126.05,43.05 126.05,40.74 124.84,39.53 124.84,39.29 124.47,38.92 124.34,38.79 123.05,38.79 v2(122.88,38.63)
  IN3 w0.135: v2(43.42,35.63) 43.2,35.84 43.2,36.19 41.1,38.29 41.1,45.54 40.16,46.49 40.16,57.01 40.29,57.15 41.56,57.15 43.09,58.67 43.09,59.99 41.21,61.87 40.21,61.87 37.22,64.85 37.22,65.69 37.44,65.91 37.44,67.01 39.3,68.87 39.3,73.24 41.44,75.39 41.44,77.39 40.67,78.16 40.47,78.16 38.99,79.64 34.22,79.64 33.26,78.68 30.3,78.68 29.44,79.54 29.44,81.35 28.1,82.69 28.1,83.75 28.23,83.88 28.23,84.79 v2(28.36,84.92)
  BOTTOM w0.102: UC1.CC8 131.9,54.39 v2(132.15,54.14)
  BOTTOM w0.112: v2(43.42,35.63) 43.2,35.41 43.2,35.23 43.43,35 45.93,35 46.88,34.05 53.42,34.05 56.92,30.55 56.92,26.13 57.92,25.13 62.55,25.13 63.72,23.96 99.18,23.96 100.13,24.91 121.83,24.91 125.84,28.92 125.84,29.7 127.67,31.52 127.67,32.51 126.56,33.61 126.56,35.49 123.25,38.8 123.05,38.8 v2(122.88,38.63) ; v2(28.36,84.92) 28.18,85.09 28.18,86.97 27.26,87.89 27.26,88.36 27.05,88.57 27.05,88.73 27.65,89.34 QI3.1
CPU_DP1_CTRL_DATA: length 215.6
  TOP w0.089: v2(131.51,54.12) 131.86,53.78 132.34,53.78 132.55,54 132.8,54 133.22,53.58 134.58,53.58 134.93,53.93 135.42,53.93 135.44,53.91 135.54,53.91
  TOP w0.112: RC8.2 144.1,53.41 143.33,53.41 142.5,54.23 140.11,54.23 139.78,53.91 135.54,53.91
  IN1 w0.089: v2(131.51,54.12) 131.67,53.97 131.67,53.84 131.48,53.65 131.23,53.65 130.78,53.21 130.78,50.33 130.21,49.76 130.21,49.56 130.18,49.53 130.18,49.46
  IN1 w0.119: v2(122.88,39.21) 123.05,39.04 124.24,39.04 124.37,39.17 124.6,39.39 124.6,39.63 125.81,40.84 125.81,43.16 127.48,44.83 127.48,46.06 128.31,46.9 128.31,47.91 128.74,48.34 129.12,48.34 130.18,49.4 130.18,49.46
  IN3 w0.135: v2(27.77,84.92) 27.97,84.72 27.97,83.99 27.84,83.86 27.84,82.58 29.18,81.24 29.18,79.43 30.2,78.42 33.37,78.42 34.33,79.38 38.88,79.38 40.36,77.9 40.57,77.9 41.18,77.29 41.18,75.5 39.04,73.35 39.04,68.98 37.18,67.12 37.18,66.02 36.96,65.8 36.96,64.75 40.1,61.6 41.1,61.6 42.83,59.88 42.83,58.78 41.45,57.41 40.18,57.41 39.9,57.12 39.9,46.38 40.84,45.43 40.84,38.18 42.94,36.08 42.94,35.74 v2(42.83,35.63)
  BOTTOM w0.102: UC1.CC9 131.25,54.39 v2(131.51,54.12)
  BOTTOM w0.112: QI3.4 26.29,88.04 26.62,88.37 26.91,88.37 27.02,88.26 27.02,87.8 27.94,86.87 27.94,85.09 v2(27.77,84.92) ; v2(122.88,39.21) 123.05,39.04 123.35,39.04 126.8,35.59 126.8,33.71 127.91,32.61 127.91,31.43 126.08,29.6 126.08,28.82 121.93,24.67 100.23,24.67 99.28,23.72 63.62,23.72 62.46,24.89 57.82,24.89 56.68,26.03 56.68,30.45 53.32,33.81 46.78,33.81 45.83,34.76 43.33,34.76 42.96,35.14 42.96,35.5 v2(42.83,35.63)
CPU_DP1_HPD: length 203.7
  IN2 w0.124: v2(14.39,112.45) 14.84,112 14.84,109.58 16.8,107.63 22.13,107.63 23.91,109.41 36.89,109.41 40.84,105.45 40.84,94.85 42.82,92.87 42.82,86.63 43.6,85.85 43.6,84.54 42.83,83.77 42.83,76.06 43.23,75.66 43.23,72.24 44.1,71.37 44.1,70.92 43.92,70.74 43.92,68.96 44.57,68.31 44.57,66.41 45.84,65.13 45.84,63.52 46.58,62.79 46.58,61.47 48.52,59.53 48.52,56.53 50.06,54.99 50.06,47.52 50.82,46.76 50.82,41.84 52.4,40.25 54.09,40.25 55.46,38.88 57.91,38.88 61.07,35.72 68.03,35.72 68.34,35.41 78.72,35.41 81.73,38.42 84.22,38.42 84.7,37.94 91.13,37.94 91.69,37.39 93.97,37.39 95.52,35.84 114.48,35.84 115.41,36.76 117.66,36.76 119.12,38.21 121.52,38.21 121.95,37.78 125.29,37.78 126.13,38.62 127.38,38.62 128.23,37.78 130.51,37.78 131.87,39.13 131.87,41.45 132.23,41.82 132.23,42.93 132.57,43.27 133.14,43.27 133.27,43.39 133.89,43.39 134.35,43.84 v2(134.43,43.84)
  BOTTOM w0.076: 133.94,45.81 133.51,46.24 133.51,47.45 133.75,47.7 133.76,47.94 133.7,48.45 133.7,48.9 UC1.CN6
  BOTTOM w0.112: QI2.3 13.57,111.56 RI13.2 v2(14.39,112.45) ; v2(134.43,43.84) 134.26,44.01 v1(134.26,44.34) 134.26,44.59 133.94,44.91 133.94,45.81
CPU_DP1_N0: length 152.1
  TOP w0.112: v2(21.28,90.61) 21.13,90.46 20.34,90.46 CI7.1
  IN3 w0.089: 129.57,76.81 129.58,76.79 129.58,76.76 130.4,75.94 132.36,75.94 132.41,75.89 133.66,75.89 133.82,75.73 133.87,75.68 133.87,75.67 133.88,75.54 v2(134.1,75.34)
  IN3 w0.135: 129.57,76.81 128.26,78.12 128.26,83.57 126.05,85.77 126.05,102.19 125.42,102.83 125.42,103.8 122.9,106.32 122.65,106.32 117.88,111.09 114.05,111.09 113.23,110.27 85.49,110.27 84.98,110.78 77.4,110.78 75.8,112.38 55.59,112.38 45.52,109.04 37.47,103.4 37.05,103.4 29.24,97.47 28.38,97.47 26.28,95.38 26.28,94.05 23.73,91.5 22.89,91.5 21.99,90.6 21.29,90.6 v2(21.28,90.61)
  BOTTOM w0.076: UC1.AL5 v2(134.1,75.34)
CPU_DP1_N1: length 152.9
  TOP w0.112: CI5.1 20.26,92.44 v2(21.6,92.44)
  IN3 w0.089: 129.57,77.79 129.58,77.77 129.58,77.74 130.02,77.3 131.2,77.3 131.64,76.86 132.38,76.86 132.4,76.83 133.07,76.83 133.28,76.61 133.28,76.48 v2(133.51,76.26)
  IN3 w0.135: 129.57,77.79 128.94,78.42 128.94,93.4 126.74,95.61 126.74,102.47 126.1,103.11 126.1,104.08 123.92,106.26 123.92,109.27 121.88,111.31 120.05,111.31 119.59,111.77 113.59,111.77 112.78,110.95 85.77,110.95 85.27,111.46 77.69,111.46 76.09,113.06 55.48,113.06 45.24,109.66 45.19,109.63 44.99,109.5 44.99,109.49 43.03,108.12 43.03,108.12 42.72,107.9 42.55,107.79 29.37,99.23 28.58,99.23 27.48,98.14 27.48,97.53 25.6,95.66 25.6,94.33 23.53,92.26 21.78,92.26 v2(21.6,92.44)
  BOTTOM w0.076: UC1.AJ5 v2(133.51,76.26)
CPU_DP1_N2: length 153.1
  TOP w0.112: v2(21.88,95.46) 21.69,95.27 21.35,95.27 21.24,95.38 21.24,95.94 20.86,96.32 20.45,96.32 CI3.1
  IN3 w0.089: v2(133.42,78.16) 133.58,78.16 133.68,78.06 133.68,77.89 133.58,77.78 131.49,77.78 131.03,78.25 130.11,78.25 129.95,78.41 129.95,81.24 129.68,81.51 129.68,81.54 129.67,81.56
  IN3 w0.135: 129.67,81.56 129.66,81.57 129.66,93.88 127.42,96.12 127.42,102.75 126.78,103.39 126.78,104.36 125.94,105.2 125.94,107.4 124.75,108.59 124.75,109.4 121.92,112.23 120.11,112.23 119.35,112.99 113.86,112.99 112.49,111.63 86.06,111.63 85.55,112.14 81.17,112.14 80.7,112.61 77.86,112.61 77.54,112.61 76.41,113.74 55.28,113.74 47.12,111.03 45.14,110.43 44.68,110.11 44.68,110.11 42.79,108.79 28.35,100.54 25.98,98.18 25.98,97.98 25.98,97 25.31,96.32 25.13,96.32 24.14,95.33 23,95.33 22.81,95.14 22.25,95.14 21.93,95.46 v2(21.88,95.46)
  BOTTOM w0.076: UC1.AF6 v2(133.42,78.16)
CPU_DP1_N3: length 153.9
  TOP w0.112: CI1.1 20.5,94.24 21.53,94.24 v2(21.62,94.34)
  IN3 w0.089: 131.47,82.1 131.47,82 131.49,81.98 131.49,79.01 131.94,78.56 132.99,78.56 133.18,78.75 133.18,78.98 133.24,79.04 133.24,79.06 133.36,79.18 v2(133.53,79.18)
  IN3 w0.135: v2(21.62,94.34) 21.44,94.52 21.24,94.52 21.14,94.41 21.14,94.09 21.07,94.02 20.77,94.02 20.66,94.13 20.66,94.98 21.7,96.02 22.88,96.02 27.28,100.42 44.52,110.77 48.44,111.96 55.13,114.18 76.6,114.18 77.73,113.05 80.88,113.05 81.36,112.58 85.73,112.58 86.24,112.07 112.04,112.07 113.52,113.54 119.42,113.54 120.28,112.68 122.1,112.68 125.26,109.52 125.26,108.71 126.52,107.45 126.52,106.21 127.21,105.52 127.21,104.45 127.86,103.81 127.86,96.31 130.22,93.94 130.22,93.05 131.47,91.8 131.47,82.1
  BOTTOM w0.076: UC1.AE5 v2(133.53,79.18)
CPU_DP1_P0: length 152.1
  TOP w0.112: CI8.1 20.55,90.24 21.06,90.24 v2(21.28,90.01)
  IN3 w0.089: v2(133.49,75.31) 133.62,75.32 133.72,75.42 133.69,75.59 133.58,75.7 132.33,75.7 132.28,75.75 130.32,75.75 129.44,76.63 129.41,76.63 129.4,76.64
  IN3 w0.135: 129.4,76.64 128.02,78.02 128.02,83.47 125.81,85.67 125.81,102.09 125.18,102.73 125.18,103.7 122.8,106.07 122.55,106.07 117.78,110.84 114.15,110.84 113.33,110.03 85.39,110.03 84.88,110.54 77.3,110.54 75.7,112.14 55.63,112.14 45.63,108.82 45.63,108.82 37.54,103.15 37.14,103.15 29.33,97.23 28.48,97.23 26.52,95.28 26.52,93.95 23.83,91.26 22.99,91.26 22.09,90.36 21.63,90.36 21.46,90.18 21.45,90.18 v2(21.28,90.01)
  BOTTOM w0.076: UC1.AL6 v2(133.49,75.31)
CPU_DP1_P1: length 153
  TOP w0.112: v2(21.6,91.86) 21.29,92.17 20.41,92.17 20.08,91.84 CI6.1
  IN3 w0.089: 129.4,77.62 129.41,77.6 129.45,77.6 129.94,77.11 131.12,77.11 131.57,76.67 132.3,76.67 132.32,76.65 132.4,76.65 132.4,76.65 132.99,76.65 133.11,76.54 133.11,76.44 132.93,76.26 v2(132.88,76.26)
  IN3 w0.135: v2(21.6,91.86) 21.76,92.02 23.63,92.02 25.84,94.23 25.84,95.56 27.72,97.43 27.72,98.04 28.68,98.99 29.37,98.99 29.5,99.03 42.68,107.58 42.86,107.71 43.17,107.92 43.17,107.93 45.13,109.3 45.13,109.3 45.31,109.42 45.34,109.44 55.52,112.82 75.99,112.82 77.59,111.22 85.17,111.22 85.67,110.71 112.88,110.71 113.69,111.53 119.49,111.53 119.95,111.07 121.78,111.07 123.68,109.17 123.68,106.16 125.86,103.98 125.86,103.01 126.49,102.37 126.49,95.51 128.7,93.3 128.7,78.32 129.4,77.62
  BOTTOM w0.076: UC1.AJ6 v2(132.88,76.26)
CPU_DP1_P2: length 153
  TOP w0.112: v2(21.88,94.87) 21.71,95.05 21.26,95.05 21.02,95.29 21.02,95.85 20.77,96.1 20.45,96.1 CI4.1
  IN3 w0.089: v2(134.06,78.15) 133.86,77.96 133.86,77.8 133.66,77.59 131.43,77.59 130.96,78.07 130.04,78.07 129.77,78.34 129.77,81.14 129.55,81.37 129.51,81.37 129.49,81.39
  IN3 w0.135: v2(21.88,94.87) 21.9,94.9 22.91,94.9 23.1,95.09 24.24,95.09 25.23,96.08 25.41,96.08 26.22,96.9 26.22,98.08 28.49,100.35 42.92,108.58 44.82,109.91 44.82,109.91 45.24,110.21 47.19,110.8 55.32,113.5 76.31,113.5 77.44,112.37 77.76,112.37 77.96,112.37 80.6,112.37 81.07,111.9 85.45,111.9 85.96,111.39 112.59,111.39 113.96,112.75 119.25,112.75 120.01,111.99 121.82,111.99 124.51,109.3 124.51,108.49 125.7,107.3 125.7,105.1 126.54,104.26 126.54,103.29 127.17,102.65 127.17,96.02 129.41,93.78 129.41,81.47 129.49,81.39
  BOTTOM w0.076: UC1.AF5 v2(134.06,78.15)
CPU_DP1_P3: length 153.8
  TOP w0.112: CI2.1 20.4,94.02 21.36,94.02 21.62,93.75 v2(21.62,93.75)
  IN3 w0.089: v2(132.88,79.19) 133,79.06 133,78.82 132.91,78.74 132.03,78.74 131.69,79.08 131.69,81.98 131.71,82
  IN3 w0.135: v2(21.62,93.75) 21.6,93.78 20.67,93.78 20.42,94.03 20.42,95.08 21.6,96.26 22.78,96.26 27.13,100.61 44.42,110.99 48.37,112.19 55.09,114.42 76.7,114.42 77.83,113.29 80.98,113.29 81.46,112.82 85.83,112.82 86.34,112.31 111.94,112.31 113.42,113.79 119.52,113.79 120.38,112.92 122.2,112.92 125.5,109.62 125.5,108.81 126.76,107.55 126.76,106.31 127.45,105.62 127.45,104.55 128.1,103.91 128.1,96.41 130.46,94.04 130.46,93.15 131.71,91.9 131.71,82 131.71,82
  BOTTOM w0.076: UC1.AE6 v2(132.88,79.19)
CPU_DP2_AUXN: length 122.4
  TOP w0.112: v2(216.18,35.28) 216.31,35.41 216.47,35.41 216.85,35.03 216.9,35.03 217.18,34.75 JVGA1.9
  IN3 w0.135: v2(216.18,35.28) 215.17,35.28 214.8,35.65 214.8,38.32 217.87,41.39 217.87,44.05 219.14,45.31 219.14,57.94 216.21,60.87 210.92,60.87 209.46,59.41 205.61,59.41 202.03,62.99 200.15,62.99 198.54,64.6 194.2,64.6 193.51,65.29 184.12,65.29 177.22,72.18 174.48,72.18 173.27,73.38 163.7,73.38 162.06,75.02 150.75,75.02 149.95,75.82 148.19,75.82 148.01,75.65 147.65,75.65 v2(147.48,75.48)
  BOTTOM w0.076: 140.34,75.38 140.33,75.39 140.33,75.43 139.54,76.22 139.08,76.22 136.72,78.59 135.5,78.59 135.29,78.68 UC1.AD4
  BOTTOM w0.112: 140.34,75.38 140.83,74.89 146.18,74.89 146.94,75.66 147.3,75.66 v2(147.48,75.48)
CPU_DP2_AUXP: length 122.4
  TOP w0.112: v2(216.18,35.86) 216.41,35.63 216.56,35.63 216.94,35.25 JVGA1.8
  IN3 w0.135: v2(216.18,35.86) 216.16,35.86 215.82,35.52 215.27,35.52 215.05,35.75 215.05,38.22 218.11,41.29 218.11,43.95 219.38,45.21 219.38,58.04 216.31,61.11 210.82,61.11 209.36,59.65 205.71,59.65 202.13,63.23 200.25,63.23 198.64,64.84 194.3,64.84 193.61,65.53 184.22,65.53 177.32,72.42 174.58,72.42 173.37,73.62 163.8,73.62 162.16,75.26 150.85,75.26 150.05,76.07 148.09,76.07 147.91,75.89 147.65,75.89 v2(147.48,76.06)
  BOTTOM w0.076: 140.5,75.54 140.48,75.55 140.44,75.55 139.61,76.39 139.15,76.39 136.79,78.75 136.03,78.75 135.95,78.83 135.95,79.08 135.87,79.16 135.75,79.16 135.74,79.16 135.63,79.16 135.5,79.03 135.5,78.92 UC1.AD3
  BOTTOM w0.112: v2(147.48,76.06) 147.3,75.88 146.85,75.88 146.09,75.11 140.92,75.11 140.5,75.54
CPU_DP2_CTRL_DATA: length 4.3
  BOTTOM w0.076: 138.8,51.37 138.78,51.37 v1(138.65,51.5) 138.32,51.82 137.12,51.82 136.94,52 UC1.CH3
  BOTTOM w0.112: RC9.2 138.8,51.37
CPU_DP2_HPD: length 119.3
  TOP w0.112: v2(219.57,32.41) 218.58,32.41 218.23,32.75 JVGA1.13
  IN3 w0.135: v2(219.57,32.41) 218.8,31.63 216.09,31.63 215.38,30.93 181.58,30.93 177.36,26.7 172.36,26.7 171.41,27.66 170.4,27.66 168.87,29.18 164.07,29.18 163.47,29.79 158.45,29.79 157.46,28.8 149.09,28.8 144.45,33.43 144.45,34.21 142.15,36.51 140.48,36.51 140.25,36.28 135.85,36.28 133.83,38.3 133.83,41.37 135.38,42.93 135.38,43.85 135.42,43.88 v2(135.42,45.27)
  BOTTOM w0.076: UC1.CM6 133.54,49.94 133.86,49.62 135.1,49.62 135.12,49.64 135.35,49.64 135.54,49.45 135.54,48.83 135.63,48.74 135.63,48.74 135.63,48.36 135.73,48.26 135.73,46.73
  BOTTOM w0.112: 135.73,46.73 135.73,45.84 135.42,45.52 v2(135.42,45.27) 135.42,45.09 136.31,44.2 139.91,44.2 141.13,42.98 v1(141.6,42.98) RC12.2
CPU_DP2_N0: length 121.1
  TOP w0.112: JVGA1.3 218.19,37.75 218.22,37.78 219,37.78 v2(219.16,37.62)
  IN3 w0.135: v2(219.16,37.62) 219.7,37.62 219.98,37.89 219.98,43.89 220.79,44.7 220.79,58.56 216.88,62.47 210.08,62.47 208.62,61.01 206.27,61.01 202.69,64.6 200.82,64.6 198.13,67.29 197.1,67.57 186.19,67.57 179.98,73.78 175.14,73.78 173.9,75.02 164.33,75.02 162.73,76.62 159.98,76.62 158.69,77.91 155.19,77.91 155.05,78.05 v2(147.48,78.05)
  BOTTOM w0.076: UC1.AC4 135.05,79.67 135.47,79.67 135.56,79.75 135.76,79.84 136.02,79.84 136.11,79.81 136.33,79.81 136.43,79.84 136.64,79.84 136.84,79.77 136.89,79.73 136.95,79.7 136.99,79.7 139.04,77.66 140.24,77.66 140.44,77.46 140.48,77.46 140.5,77.44
  BOTTOM w0.112: 140.5,77.44 141.49,76.45 144.83,76.45 146.43,78.05 v2(147.48,78.05)
CPU_DP2_N1: length 120.3
  TOP w0.112: JVGA1.6 217.21,36.25 216.93,36.53 216.74,36.53 216.71,36.56 v2(216.44,36.56)
  IN3 w0.135: v2(216.44,36.56) 217.23,36.56 217.59,36.91 217.59,39.8 218.79,41 218.79,43.66 220.06,44.93 220.06,58.33 216.6,61.79 210.37,61.79 208.91,60.33 205.99,60.33 202.41,63.91 200.54,63.91 198.67,65.78 198.11,65.78 197.01,66.89 185.91,66.89 179.69,73.1 174.86,73.1 173.62,74.34 164.05,74.34 162.45,75.94 159.7,75.94 158.57,77.07 v2(148.75,77.07)
  BOTTOM w0.076: 140.5,76.49 140.48,76.5 140.44,76.5 139.9,77.05 139.12,77.05 137.07,79.09 136.35,79.09 136.29,79.15 136.29,79.41 136.34,79.46 136.5,79.46 UC1.AC1
  BOTTOM w0.112: 140.5,76.49 141.17,75.81 v4(144.05,75.81) 145.83,75.81 146.91,76.89 147.8,76.89 147.98,77.07 v2(148.75,77.07)
CPU_DP2_P0: length 121.1
  TOP w0.112: v2(219.07,38.21) 218.86,38 218.38,38 218.13,38.25 JVGA1.2
  IN3 w0.135: v2(219.07,38.21) 219.23,38.04 219.34,38.04 219.52,37.86 219.6,37.86 219.74,37.99 219.74,43.99 220.55,44.8 220.55,58.46 216.78,62.23 210.18,62.23 208.72,60.77 206.17,60.77 202.59,64.35 200.72,64.35 198,67.07 197.91,67.1 197.06,67.33 186.09,67.33 179.88,73.54 175.04,73.54 173.8,74.78 164.23,74.78 162.63,76.38 159.88,76.38 158.59,77.67 155.09,77.67 154.95,77.8 148.14,77.8 147.96,77.63 147.96,77.43 147.87,77.33 147.61,77.33 v2(147.48,77.46)
  BOTTOM w0.076: UC1.AC3 135.19,79.41 135.11,79.34 135.11,79.21 135.18,79.14 135.37,79.14 135.58,79.34 135.58,79.54 135.65,79.61 135.8,79.68 135.99,79.68 136.08,79.64 136.36,79.64 136.46,79.68 136.61,79.68 136.76,79.62 136.81,79.58 136.91,79.53 136.92,79.53 138.97,77.49 140.17,77.49 140.33,77.34 140.33,77.3 140.34,77.29
  BOTTOM w0.112: v2(147.48,77.46) 147.12,77.82 146.52,77.82 144.92,76.23 141.4,76.23 140.34,77.29
CPU_DP2_P1: length 120.3
  TOP w0.112: JVGA1.5 216.83,36.75 216.44,37.14 216.44,37.15 v2(216.44,37.15)
  IN3 w0.135: v2(216.44,37.15) 216.44,37.15 216.44,37.14 216.6,36.98 216.62,36.98 216.8,36.8 217.13,36.8 217.34,37.01 217.34,39.9 218.55,41.11 218.55,43.76 219.82,45.03 219.82,58.23 216.5,61.55 210.47,61.55 209.01,60.09 205.89,60.09 202.31,63.67 200.43,63.67 198.57,65.54 198.01,65.54 196.91,66.65 185.81,66.65 179.59,72.86 174.76,72.86 173.52,74.1 163.95,74.1 162.35,75.7 159.6,75.7 158.47,76.83 149.32,76.83 149.21,76.72 149.21,76.65 149.07,76.51 148.78,76.51 v2(148.75,76.49)
  BOTTOM w0.076: 140.34,76.33 140.33,76.35 140.33,76.39 139.83,76.88 139.05,76.88 137,78.93 136.28,78.93 136.13,79.08 136.13,79.29 136.01,79.41 UC1.AC2
  BOTTOM w0.112: v2(148.75,76.49) 148.48,76.49 148.37,76.6 148.37,76.77 148.28,76.85 148.07,76.85 147.89,76.67 147,76.67 145.92,75.59 144.33,75.59 144.32,75.58 143.79,75.58 143.77,75.59 141.08,75.59 140.34,76.33
CPU_POPIRCOMP: length 1.4
  TOP w0.254: RC15.1 120.4,59.33 v2(119.88,59.85)
  BOTTOM w0.2: v2(119.88,59.85) UC1.BP27
CPU_SPI_0_CLK: length 25.6
  BOTTOM w0.102: 112.4,48.18 112.4,50.52 UC1.CH37
  BOTTOM w0.112: RC187.2 113.45,34.04 RC21.2 112.56,33.66 112.56,34.01 112.82,34.27 112.82,34.74 112.56,35 110.83,35 108.91,36.92 108.75,36.92 108.53,36.69 108.37,36.69 108.21,36.85 108.21,37.01 108.44,37.23 108.44,37.39 108.27,37.56 108.27,40.95 v1(108.68,41.77) 109.94,44.28 110.83,45.17 110.83,46.28 112.4,47.86 112.4,48.18
CPU_SPI_0_CS#0: length 50.8
  TOP w0.112: v2(123.6,39.46) 123.44,39.62 122.71,39.62 122.13,39.05 119.85,39.05 119.57,38.77 119.57,37.74 120.88,36.44 120.88,34.22 120.34,33.67 117.43,33.67 115.73,35.38 110.26,35.38 v3(109.23,36.4) v2(107.76,37.87)
  BOTTOM w0.102: 111.67,48.33 111.67,50.73 113.62,52.69 UC1.CG36
  BOTTOM w0.112: v2(123.61,39.46) 123.61,39.36 125.25,37.71 126.73,37.71 127.05,37.4 UC3.1 130.51,37.4 RC31.2 ; v2(107.76,37.87) 107.36,38.27 107.36,41.98 108.19,42.81 108.19,43.74 108.9,44.46 108.9,45.57 111.67,48.33
CPU_SPI_0_CS#1: length 56.5
  TOP w0.112: v2(126.2,37.23) 126.2,35.41 124.1,33.31 117.28,33.31 117.11,33.48 117.1,33.48 v1(116.42,34.16) 115.57,35.01 109.97,35.01 107.25,37.73 107.25,38.15 107.68,38.58 v2(107.77,38.58)
  BOTTOM w0.076: UC1.CG35 114.8,52.69 114.42,52.31 113.71,52.31 112.02,50.62
  BOTTOM w0.112: 112.02,50.62 112.02,50.62 112.02,48.17 110.34,46.49 110.34,45.38 108.55,43.59 108.55,42.66 107.77,41.88 v2(107.77,38.58) ; v2(126.2,37.23) 127.06,36.37 127.06,33.82 129.09,31.78 131.87,31.78 132.24,32.15 UC11.1 132.24,33.38 132,33.63 130.87,33.63 130.72,33.78 130.72,34.81 RC207.2
