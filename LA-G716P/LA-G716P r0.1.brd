# Allegro board LA-G716P r0.1.brd (continued)
## Placement (name value [footprint] x y rotation side) (continued)
NOREF#15  -  []  137.38 39.81 0 top
NOREF#16  -  []  213.85 65.5 0 top
NOREF#17  -  []  6.9 112.6 0 top
NOREF#18  -  []  126.01 153.05 0 top
NOREF#19  -  []  87.16 82.99 0 top
NOREF#20  -  []  101.31 130.35 0 top
NOREF#21  -  []  63.76 36.13 0 top
NOREF#22  -  []  6.9 112.6 0 top
NOREF#23  -  []  8 41.2 0 top
NOREF#24  -  []  95.92 50.35 180 bottom
NOREF#25  -  []  133.97 94.71 180 bottom
NOREF#26  -  []  135.21 101.54 180 bottom
PBATT1  -  [ACES_50458-01001-P01_10P-T]  173.01 40 180 bottom
PC1  2200P_0402_50V7K  [C_0402]  83.04 141.41 180 top
PC2  100P_0402_25V8K  [C_0402]  83.04 140.39 180 top
PC3  2200P_0402_50V7K  [C_0402]  84.17 147.87 90 top
PC4  100P_0402_25V8K  [C_0402]  85.19 147.87 90 top
PC5  1000P_0402_50V7K  [C_0402]  94.01 148.45 90 bottom
PC6  1000P_0402_50V7K  [C_0402]  95.67 148.45 90 bottom
PC11  0.01U_0402_25V7K  [C_0402]  173.97 41.97 180 bottom
PC12  1000P_0402_50V7K  [C_0402]  177.71 36.46 270 bottom
PC13  .1U_0402_16V7K  [C_0402]  170.21 34.02 90 top
PC14  .1U_0402_16V7K  [C_0402]  165.01 38.68 270 top
PC15  10P_0402_25V8J  [C_0402]  83.04 142.43 180 top
PC301  1000P_0402_25V8J  [C_0402]  14.03 38.94 180 bottom
PC302  2200P_0402_50V7K  [C_0402]  15.53 41.07 90 bottom
PC303  4.7U_0603_25V6K  [C_0603]  17.81 41.97 90 top
PC304  4.7U_0603_25V6K  [C_0603]  16.67 41.02 90 bottom
PC305  0.1U_0402_25V6  [C_0402]  14.04 40.77 180 bottom
PC306  1000P_0402_25V8J  [C_0402]  14.03 39.87 180 bottom
PC307  0.1U_0402_10V7K  [C_0402]  23.35 40.42 90 bottom
PC308  4.7U_0402_6.3V6M  [C_0402]  20.98 43.85 270 top
PC309  680P_0603_50V7K  [C_0603]  22.65 44.38 270 top
PC310  22U_0603_6.3V6M  [C_0603]  24.42 52.57 180 bottom
PC311  22U_0603_6.3V6M  [C_0603]  27.5 52.84 0 bottom
PC312  22U_0603_6.3V6M  [C_0603]  24.42 52.57 180 top
PC313  22U_0603_6.3V6M  [C_0603]  27.5 52.84 0 top
PC314  22U_0603_6.3V6M  [C_0603]  24.42 53.84 180 bottom
PC315  1000P_0402_25V8J  [C_0402]  21.51 46.11 90 bottom
PC316  22U_0603_6.3V6M  [C_0603]  24.42 53.84 180 top
PC317  1U_0402_25V6K  [C_0402]  19.82 47.28 90 top
PC501  1000P_0402_25V8J  [C_0402]  25.7 101.82 180 bottom
PC502  2200P_0402_50V7K  [C_0402]  25.7 102.71 180 bottom
PC503  10U_0603_25V6M  [C_0603]  28.93 99.08 270 top
PC504  10U_0603_25V6M  [C_0603]  28.96 99.08 270 bottom
PC505  0.1U_0402_25V6  [C_0402]  25.7 100.94 180 bottom
PC506  1000P_0402_25V8J  [C_0402]  25.7 100.05 180 bottom
PC507  0.1U_0402_10V7K  [C_0402]  23.61 102.55 90 bottom
PC508  4.7U_0402_6.3V6M  [C_0402]  23.95 96.87 90 top
PC509  680P_0603_50V7K  [C_0603]  19.1 100.93 90 top
PC510  22U_0603_6.3V6M  [C_0603]  23.91 106.61 270 top
PC511  22U_0603_6.3V6M  [C_0603]  25.12 106.61 270 top
PC512  22U_0603_6.3V6M  [C_0603]  27.53 106.61 270 bottom
PC513  22U_0603_6.3V6M  [C_0603]  25.12 106.61 270 bottom
PC514  22U_0603_6.3V6M  [C_0603]  23.91 106.61 270 bottom
PC515  4.7U_0402_6.3V6M  [C_0402]  24.63 95.79 0 top
PC516  4.7U_0402_6.3V6M  [C_0402]  26.6 92.34 180 bottom
PC517  1000P_0402_25V8J  [C_0402]  24.8 93.23 270 bottom
PC519  22U_0603_6.3V6M  [C_0603]  23.59 103.25 0 top
PC520  22U_0603_6.3V6M  [C_0603]  26.32 106.61 270 bottom
PC521  22U_0603_6.3V6M  [C_0603]  26.32 106.61 270 top
PC1801  22U_0603_6.3V6M  [C_0603]  204.64 52.58 180 bottom
PC1802  22U_0603_6.3V6M  [C_0603]  197.07 60.51 0 top
PC1803  22U_0603_6.3V6M  [C_0603]  197.07 60.51 0 bottom
PC1804  22U_0603_6.3V6M  [C_0603]  197.07 61.72 0 bottom
PC1805  0.1U_0402_10V7K  [C_0402]  201.89 57.08 0 bottom
PC1806  680P_0402_50V7K  [C_0402]  201.14 55.18 0 top
PC1807  22P_0402_50V8J  [C_0402]  204.5 57.92 270 bottom
PC2501  22U_0603_6.3V6M  [C_0603]  73.62 113.39 90 top
PC2502  22U_0603_6.3V6M  [C_0603]  64.3 113.5 90 top
PC2503  0.1U_0402_10V6K  [C_0402]  73.31 111.49 90 top
PC2504  2.2U_0402_6.3V6K  [C_0402]  72.17 115.43 90 top
PC2505  0.01U_0402_25V7K  [C_0402]  64.74 112.42 270 top
PC2506  4.7U_0402_6.3V6M  [C_0402]  27.34 94.12 270 bottom
PCA01  10U_0603_25V6M  [C_0603]  165.07 54.03 270 top
PCA02  10U_0603_25V6M  [C_0603]  165.07 54.03 270 bottom
PCA03  0.1U_0402_25V6  [C_0402]  163.93 56.88 90 bottom
PCA04  2200P_0402_50V7K  [C_0402]  161.07 56.88 90 bottom
PCA05  1000P_0402_50V7K  [C_0402]  162.02 56.88 90 bottom
PCA06  1000P_0402_50V7K  [C_0402]  162.98 56.88 90 bottom
PCA07  0.47U_0402_25V6K  [C_0402]  167 53.86 270 top
PCA08  2.2U_0402_16V6K  [C_0402]  169.02 51.24 180 bottom
PCA09  680P_0603_50V7K  [C_0603]  163.42 53.97 270 top
PCA101  22U_0603_6.3V6M  [C_0603]  152.12 53.53 270 top
PCA102  22U_0603_6.3V6M  [C_0603]  128.89 63.1 270 top
PCA103  22U_0603_6.3V6M  [C_0603]  128.89 64.18 90 top
PCA104  22U_0603_6.3V6M  [C_0603]  127.62 64.18 90 top
PCA105  22U_0603_6.3V6M  [C_0603]  126.39 63.15 270 top
PCA106  22U_0603_6.3V6M  [C_0603]  152.12 53.53 270 bottom
PCA107  22U_0603_6.3V6M  [C_0603]  127.62 63.1 270 top
PCA108  22U_0603_6.3V6M  [C_0603]  125.12 64.18 90 top
PCA109  22U_0603_6.3V6M  [C_0603]  126.39 64.18 90 top
PCA110  1U_0201_6.3V6M  [C_0201]  131.1 62.2 270 top
PCA111  1U_0201_6.3V6M  [C_0201]  130.46 62.2 270 top
PCA112  1U_0201_6.3V6M  [C_0201]  131.55 64.46 90 top
PCA113  1U_0201_6.3V6M  [C_0201]  129.83 64.92 90 top
PCA114  1U_0201_6.3V6M  [C_0201]  124.18 62.15 270 top
PCA115  1U_0201_6.3V6M  [C_0201]  129.83 62.2 270 top
PCA117  22U_0603_6.3V6M  [C_0603]  125.12 63.15 270 top
PCA118  22U_0603_6.3V6M  [C_0603]  153.2 56.45 90 bottom
PCB01  0.1U_0402_25V6  [C_0402]  192.17 58.61 0 top
PCB02  0.01UF_0402_25V7K  [C_0402]  202.4 47.05 0 top
PCB03  0.1U_0402_25V6  [C_0402]  200.76 47.32 270 bottom
PCB04  0.033U_0402_25V7K  [C_0402]  199.82 48.57 180 bottom
PCB05  1U_0402_25V6K  [C_0402]  199.82 46.1 180 bottom
PCB06  0.47U_0402_25V6K  [C_0402]  198.92 43.56 0 bottom
PCB07  1U_0402_25V6K  [C_0402]  202.35 49.59 90 bottom
PCB08  2.2U_0402_6.3V6K  [C_0402]  203.55 48.09 90 top
PCB09  10P_0402_50V8J  [C_0402]  207.81 49.51 90 bottom
PCB10  2200P_0402_25V7K  [C_0402]  209.66 48 180 bottom
PCB11  0.033U_0402_25V7K  [C_0402]  210.54 45.32 90 bottom
PCB12  560P_0402_50V7K  [C_0402]  208.75 46.22 0 bottom
PCB13  0.1U_0402_25V6  [C_0402]  209.66 46.22 180 top
PCB14  0.1U_0402_25V6  [C_0402]  208.75 43.62 0 top
PCB15  0.1U_0402_25V6  [C_0402]  208 42.72 90 bottom
PCB16  0.22U_0402_25V6K  [C_0402]  206.54 43.42 90 top
PCB17  1U_0402_25V6K  [C_0402]  205.65 43.42 90 top
PCB18  0.47U_0402_25V6K  [C_0402]  205.14 41.65 180 bottom
PCB19  2.2U_0402_6.3V6K  [C_0402]  202.73 41.85 270 bottom
PCB20  10U_0603_25V6M  [C_0603]  194.79 46.29 0 top
PCB21  10U_0603_25V6M  [C_0603]  194.79 45.02 0 top
PCB22  10U_0603_25V6M  [C_0603]  194.79 45.02 0 bottom
PCB23  10U_0603_25V6M  [C_0603]  194.79 46.29 0 bottom
PCB24  0.1U_0402_25V7K  [C_0402]  194.78 47.43 0 bottom
PCB25  2200P_0402_25V7K  [C_0402]  194.9 43.87 0 bottom
PCB26  1000P_0402_25V8J  [C_0402]  194.78 48.32 0 bottom
PCB27  1000P_0402_25V8J  [C_0402]  194.9 42.98 0 bottom
PCB28  0.1U_0402_25V7K  [C_0402]  180.63 50.05 270 bottom
PCB29  680P_0603_50V7K  [C_0603]  191.93 41.14 0 top
PCB30  10U_0603_25V6M  [C_0603]  172.44 45.14 180 bottom
PCB31  10U_0603_25V6M  [C_0603]  173.83 41.97 180 top
PCB32  10U_0603_25V6M  [C_0603]  173.96 43.11 180 bottom
PCB33  10U_0603_25V6M  [C_0603]  173.83 43.24 180 top
PCB34  10U_0603_25V6M  [C_0603]  173.83 40.7 180 top
PCB35  0.1U_0402_25V7K  [C_0402]  177.96 37.47 270 top
PCB36  0.047U_0402_25V7K  [C_0402]  203.88 52.57 180 top
PCB70  15U_B2_25VM_R100M  [C_B2]  188.48 54.67 0 bottom
PCB71  1U_0402_25V6K  [C_0402]  201.46 50.14 90 bottom
PCC01  22U_0603_6.3V6M  [C_0603]  127.08 81.43 90 top
PCC02  22U_0603_6.3V6M  [C_0603]  131.47 75.84 180 top
PCC03  22U_0603_6.3V6M  [C_0603]  128.29 81.43 90 top
PCC04  22U_0603_6.3V6M  [C_0603]  129.5 81.43 90 top
PCG01  10U_0603_25V6M  [C_0603]  163.36 92.83 270 bottom
PCG02  10U_0603_25V6M  [C_0603]  163.36 92.83 270 top
PCG03  10U_0603_25V6M  [C_0603]  164.63 92.83 270 bottom
PCG04  10U_0603_25V6M  [C_0603]  164.63 92.83 270 top
PCG05  0.1U_0402_25V6  [C_0402]  168.16 90.15 180 bottom
PCG06  2200P_0402_50V7K  [C_0402]  168.16 91.04 180 bottom
PCG07  1000P_0402_50V7K  [C_0402]  166.59 92.91 270 bottom
PCG08  1000P_0402_50V7K  [C_0402]  165.71 92.91 270 bottom
PCG09  0.47U_0402_25V6K  [C_0402]  161.29 97.9 270 bottom
PCG10  1U_0402_16V6K  [C_0402]  158.99 96.73 90 bottom
PCG11  1U_0402_16V6K  [C_0402]  157.13 93.98 270 top
PCG12  680P_0603_50V8J  [C_0603]  156.12 90.76 90 top
PCG13  33U_D2_25VM_R40M  [C_EEFCX1E330R]  165.86 95.39 270 bottom
PCG101  22U_0603_6.3V6M  [C_0603]  147.52 105.36 90 bottom
PCG102  22U_0603_6.3V6M  [C_0603]  129.2 86.97 270 top
PCG103  22U_0603_6.3V6M  [C_0603]  131.87 90.91 90 top
PCG104  22U_0603_6.3V6M  [C_0603]  125.52 86.53 270 top
PCG105  22U_0603_6.3V6M  [C_0603]  146.29 105.35 90 top
PCG106  22U_0603_6.3V6M  [C_0603]  150.05 106.46 0 top
PCG107  22U_0603_6.3V6M  [C_0603]  133.14 90.91 90 top
PCG108  22U_0603_6.3V6M  [C_0603]  128 86.97 270 top
PCG109  22U_0603_6.3V6M  [C_0603]  128.95 89.39 0 top
PCG110  22U_0603_6.3V6M  [C_0603]  126.79 86.97 270 top
PCG111  22U_0603_6.3V6M  [C_0603]  150.05 105.25 0 top
PCG112  22U_0603_6.3V6M  [C_0603]  147.51 105.37 90 top
PCG113  22U_0603_6.3V6M  [C_0603]  150.05 105.25 0 bottom
PCG114  22U_0603_6.3V6M  [C_0603]  144.59 105.48 180 top
PCG115  22U_0603_6.3V6M  [C_0603]  126.09 88.75 180 top
PCG116  22U_0603_6.3V6M  [C_0603]  150.05 106.46 0 bottom
PCG117  22U_0603_6.3V6M  [C_0603]  126.09 90.02 180 top
PCG118  22U_0603_6.3V6M  [C_0603]  148.73 105.37 90 bottom
PCG119  22U_0603_6.3V6M  [C_0603]  128.94 91.31 0 top
PCG120  22U_0603_6.3V6M  [C_0603]  124.31 86.53 270 top
PCG121  1U_0201_6.3V6M  [C_0201]  122.08 86.63 90 top
PCG122  1U_0201_6.3V6M  [C_0201]  121.48 86.67 180 top
PCG123  1U_0201_6.3V6M  [C_0201]  131.61 93.7 270 top
PCG124  1U_0201_6.3V6M  [C_0201]  121.48 84.96 180 top
PCG125  1U_0201_6.3V6M  [C_0201]  121.48 84.39 180 top
PCG126  1U_0201_6.3V6M  [C_0201]  124.82 87.85 180 top
PCG127  1U_0201_6.3V6M  [C_0201]  132.16 87.14 180 top
PCG128  1U_0201_6.3V6M  [C_0201]  121.48 83.82 180 top
PCG129  1U_0201_6.3V6M  [C_0201]  121.48 86.1 180 top
PCG130  1U_0201_6.3V6M  [C_0201]  124.82 87.29 180 top
PCG131  1U_0201_6.3V6M  [C_0201]  121.48 85.53 180 top
PCG132  22U_0603_6.3V6M  [C_0603]  146.29 105.35 90 bottom
PCG133  22U_0603_6.3V6M  [C_0603]  148.73 105.37 90 top
PCG134  22U_0603_6.3V6M  [C_0603]  144.59 105.48 180 bottom
PCG135  1U_0201_6.3V6M  [C_0201]  130.72 92.93 270 top
PCG171  330U_D2_2V_Y  [C_D2]  149.62 102.26 0 bottom
PCG172  330U_D2_2V_Y  [C_D2]  145.23 102.81 270 bottom
PCH01  0.1U_0402_25V6  [C_0402]  161.53 48.32 180 top
PCH02  2200P_0402_50V7K  [C_0402]  161.53 49.08 180 bottom
PCH03  10U_0603_25V6M  [C_0603]  162.02 48 180 bottom
PCH04  10U_0603_25V6M  [C_0603]  162.02 47.24 180 top
PCH05  22U_0603_6.3V6M  [C_0603]  150.02 49.72 90 bottom
PCH06  22U_0603_6.3V6M  [C_0603]  151.23 49.72 90 top
PCH07  22U_0603_6.3V6M  [C_0603]  151.23 49.72 90 bottom
PCH08  22U_0603_6.3V6M  [C_0603]  150.02 49.72 90 top
PCH09  0.1U_0402_25V6  [C_0402]  164.44 45.28 270 top
PCH10  1U_0402_10V6K  [C_0402]  164.37 45.32 90 bottom
PCH11  1U_0402_10V6K  [C_0402]  164.17 42.73 0 bottom
PCH12  0.1U_0402_10V6K  [C_0402]  161.15 41.97 180 bottom
PCH13  680P_0603_50V7K  [C_0603]  158.34 44.06 0 top
PCH14  330P_0402_50V7K  [C_0402]  166.16 45.27 180 bottom
PCH15  1000P_0402_50V7K  [C_0402]  158.71 49.08 0 bottom
PCH16  1000P_0402_50V7K  [C_0402]  161.53 49.21 180 top
PCI01  10U_0603_25V6M  [C_0603]  165.83 80.01 180 top
PCI02  10U_0603_25V6M  [C_0603]  166.66 67.94 90 bottom
PCI03  10U_0603_25V6M  [C_0603]  167.61 65.21 270 bottom
PCI04  10U_0603_25V6M  [C_0603]  165.83 81.59 180 top
PCI05  1000P_0402_50V7K  [C_0402]  168.49 72.64 0 bottom
PCI06  0.1U_0402_25V6  [C_0402]  167.24 70.67 180 bottom
PCI07  2200P_0402_50V7K  [C_0402]  167.24 71.56 180 bottom
PCI08  1000P_0402_50V7K  [C_0402]  168.49 71.69 0 bottom
PCI09  0.47U_0402_25V6K  [C_0402]  165.26 69.34 270 bottom
PCI10  1U_0402_16V6K  [C_0402]  162.53 66.64 0 top
PCI11  1U_0402_16V6K  [C_0402]  161.38 64.75 270 top
PCI12  680P_0603_50V8J  [C_0603]  159.63 62.76 90 top
PCI13  33U_D2_25VM_R40M  [C_EEFCX1E330R-NPM]  167.59 75.51 0 bottom
PCI14  33U_25V_M  [C_6P3X4P5]  167.37 75.51 180 bottom
PCI21  0.1U_0402_25V6  [C_0402]  168.28 83.75 0 bottom
PCI22  2200P_0402_50V7K  [C_0402]  166.2 83.24 180 top
PCI23  10U_0603_25V6M  [C_0603]  166.66 67.94 90 top
PCI24  10U_0603_25V6M  [C_0603]  165.83 81.59 180 bottom
PCI25  10U_0603_25V6M  [C_0603]  167.61 65.21 270 top
PCI26  10U_0603_25V6M  [C_0603]  165.83 80.01 180 bottom
PCI27  1000P_0402_50V7K  [C_0402]  166.2 84.18 180 top
PCI28  1000P_0402_50V7K  [C_0402]  168.26 82.81 0 bottom
PCI29  0.47U_0402_25V6K  [C_0402]  169.72 84.82 180 bottom
PCI30  1U_0402_16V6K  [C_0402]  168.23 87.27 0 bottom
PCI31  1U_0402_16V6K  [C_0402]  164.97 88.12 180 top
PCI32  680P_0603_50V8J  [C_0603]  161.42 88.24 0 top
PCI101  22U_0603_6.3V6M  [C_0603]  129.57 69.21 270 top
PCI102  22U_0603_6.3V6M  [C_0603]  124.37 76.45 270 top
PCI103  22U_0603_6.3V6M  [C_0603]  153.83 71.88 270 top
PCI104  22U_0603_6.3V6M  [C_0603]  125.64 76.45 270 top
PCI105  22U_0603_6.3V6M  [C_0603]  122.02 80.32 180 top
PCI106  22U_0603_6.3V6M  [C_0603]  156.31 79.12 270 bottom
PCI107  22U_0603_6.3V6M  [C_0603]  157.64 71.88 270 bottom
PCI108  22U_0603_6.3V6M  [C_0603]  155.1 71.88 270 top
PCI109  22U_0603_6.3V6M  [C_0603]  155.1 71.88 270 bottom
PCI110  22U_0603_6.3V6M  [C_0603]  156.37 71.88 270 bottom
PCI113  22U_0603_6.3V6M  [C_0603]  124.49 69.21 270 top
PCI114  22U_0603_6.3V6M  [C_0603]  125.76 69.21 270 top
PCI115  22U_0603_6.3V6M  [C_0603]  127.03 69.21 270 top
PCI116  22U_0603_6.3V6M  [C_0603]  128.3 69.21 270 top
PCI117  22U_0603_6.3V6M  [C_0603]  156.31 76.7 270 bottom
PCI118  22U_0603_6.3V6M  [C_0603]  152.56 71.88 270 top
PCI119  22U_0603_6.3V6M  [C_0603]  156.31 76.7 270 top
PCI120  22U_0603_6.3V6M  [C_0603]  157.64 71.88 270 top
PCI121  47U_0603_6.3V6M  [C_0603]  153.83 71.88 270 bottom
PCI122  47U_0603_6.3V6M  [C_0603]  157.64 79.12 270 bottom
PCI123  47U_0603_6.3V6M  [C_0603]  157.64 79.12 270 top
PCI124  47U_0603_6.3V6M  [C_0603]  128.18 76.45 270 top
PCI125  47U_0603_6.3V6M  [C_0603]  156.37 71.88 270 top
PCI126  47U_0603_6.3V6M  [C_0603]  157.64 76.7 270 top
PCI127  47U_0603_6.3V6M  [C_0603]  157.64 76.7 270 bottom
PCI128  47U_0603_6.3V6M  [C_0603]  123.22 69.21 270 top
PCI129  47U_0603_6.3V6M  [C_0603]  156.31 79.12 270 top
PCI130  47U_0603_6.3V6M  [C_0603]  126.91 76.45 270 top
PCI134  1U_0201_6.3V6M  [C_0201]  131.59 77.49 180 top
PCI135  1U_0201_6.3V6M  [C_0201]  131.77 78.65 180 top
PCI136  1U_0201_6.3V6M  [C_0201]  131.59 78.08 180 top
PCI137  1U_0201_6.3V6M  [C_0201]  131.69 79.56 180 top
PCI138  1U_0201_6.3V6M  [C_0201]  131.73 80.47 180 top
PCI139  1U_0201_6.3V6M  [C_0201]  131.75 81.39 180 top
PCI140  1U_0201_6.3V6M  [C_0201]  131.59 76.93 180 top
PCI151  1U_0201_6.3V6M  [C_0201]  120.56 71.47 270 top
PCI152  1U_0201_6.3V6M  [C_0201]  130.27 66.44 90 top
PCI153  1U_0201_6.3V6M  [C_0201]  131.55 66.25 270 top
PCI154  1U_0201_6.3V6M  [C_0201]  122.91 77 270 top
PCI155  1U_0201_6.3V6M  [C_0201]  122.34 77.62 90 top
PCI156  1U_0201_6.3V6M  [C_0201]  120.56 65.63 270 top
PCI157  1U_0201_6.3V6M  [C_0201]  121.19 68.49 270 top
PCI158  1U_0201_6.3V6M  [C_0201]  122.34 77 270 top
PCI159  1U_0201_6.3V6M  [C_0201]  123.55 65.66 270 top
PCI160  1U_0201_6.3V6M  [C_0201]  131.61 68.79 90 top
PCI161  1U_0201_6.3V6M  [C_0201]  131.03 68.79 90 top
PCI162  1U_0201_6.3V6M  [C_0201]  131.54 67.66 270 top
PCI163  1U_0201_6.3V6M  [C_0201]  130.97 67.66 270 top
PCI164  1U_0201_6.3V6M  [C_0201]  119.23 65.92 90 top
PCI165  1U_0201_6.3V6M  [C_0201]  120.56 72.41 90 top
PCI166  1U_0201_6.3V6M  [C_0201]  121.19 66.44 90 top
PCI167  1U_0201_6.3V6M  [C_0201]  120.56 66.44 90 top
PCI168  1U_0201_6.3V6M  [C_0201]  122.34 66.44 90 top
PCI169  1U_0201_6.3V6M  [C_0201]  120.56 68.49 270 top
PCI170  1U_0201_6.3V6M  [C_0201]  128.02 66.43 90 top
PCI171  1U_0201_6.3V6M  [C_0201]  121.13 72.41 90 top
PCI172  1U_0201_6.3V6M  [C_0201]  122.34 65.63 270 top
PCI173  1U_0201_6.3V6M  [C_0201]  129.19 66.44 90 top
PCI174  1U_0201_6.3V6M  [C_0201]  121.19 65.63 270 top
PCI175  1U_0201_6.3V6M  [C_0201]  125.76 66.44 90 top
PCI176  1U_0201_6.3V6M  [C_0201]  149.61 82.86 180 top
PCI177  1U_0201_6.3V6M  [C_0201]  124.62 66.44 90 top
PCI178  1U_0201_6.3V6M  [C_0201]  149.61 83.5 180 top
PCI179  1U_0201_6.3V6M  [C_0201]  123.48 66.44 90 top
PCI180  1U_0201_6.3V6M  [C_0201]  149.61 84.13 180 top
PCI181  1U_0201_6.3V6M  [C_0201]  121.13 71.47 270 top
PCI182  1U_0201_6.3V6M  [C_0201]  149.61 82.23 180 top
PCI183  1U_0201_6.3V6M  [C_0201]  126.91 66.44 90 top
PCI184  1U_0201_6.3V6M  [C_0201]  120.56 69.68 90 top
PCI185  1U_0201_6.3V6M  [C_0201]  121.13 69.68 90 top
PCI186  330U_D2_2V_Y  [C_D2]  150.66 82.08 90 bottom
PCI187  330U_D2_2V_Y  [C_D2]  150.67 67.03 270 bottom
PCI188  330U_D2_2V_Y  [C_D2]  145.96 81.19 90 bottom
PCI189  330U_D2_2V_Y  [C_D2]  129.73 72.03 180 top
PCM01  0.1U_0402_25V6  [C_0402]  42.9 24.85 270 bottom
PCM02  2200P_0402_50V7K  [C_0402]  41.98 24.85 270 bottom
PCM03  10U_0603_25V6M  [C_0603]  42.26 27.62 90 bottom
PCM04  10U_0603_25V6M  [C_0603]  42.26 27.62 90 top
PCM05  22U_0603_6.3V6M  [C_0603]  49.81 31.84 90 top
PCM06  22U_0603_6.3V6M  [C_0603]  49.79 31.85 90 bottom
PCM07  22U_0603_6.3V6M  [C_0603]  51.01 31.85 90 bottom
PCM08  22U_0603_6.3V6M  [C_0603]  48.6 31.85 90 bottom
PCM09  22U_0603_6.3V6M  [C_0603]  48.6 31.84 90 top
PCM10  22U_0603_6.3V6M  [C_0603]  51.01 31.84 90 top
PCM11  680P_0402_50V7K  [C_0402]  51.98 27.96 180 top
PCM12  0.1U_0402_10V7K  [C_0402]  40.83 27.48 180 top
PCM13  2.2U_0402_6.3V6K  [C_0402]  35.09 25.28 270 top
PCM14  2.2U_0402_6.3V6K  [C_0402]  31.66 25.28 270 top
PCM15  0.1U_0402_10V7K  [C_0402]  33.63 29.13 180 top
PCM16  0.1U_0402_10V7K  [C_0402]  33.64 30.06 180 top
PCM17  220P_0402_25V8J  [C_0402]  34.04 32.25 0 top
PCM18  .1U_0402_16V7K  [C_0402]  35.86 32.21 90 top
PCM19  0.033U_0402_16V7K  [C_0402]  36.78 32.19 90 top
PCM20  22U_0603_6.3V6M  [C_0603]  39.47 33.02 0 top
PCM22  1000P_0402_50V7K  [C_0402]  41.98 24.85 270 top
PCM23  1000P_0402_50V7K  [C_0402]  42.9 24.85 270 top
PCV01  10U_0603_25V6M  [C_0603]  81.78 134.78 270 bottom
PCV02  10U_0603_25V6M  [C_0603]  81.78 134.78 270 top
PCV03  4.7U_0603_25V6K  [C_0603]  83.56 134.78 270 top
PCV04  2200P_0402_50V7K  [C_0402]  82.23 139.11 180 bottom
PCV05  0.1U_0402_25V6K  [C_0402]  82.23 138.22 180 bottom
PCV06  2200P_0402_50V7K  [C_0402]  82.23 137.33 180 bottom
PCV07  0.1U_0402_25V6K  [C_0402]  82.23 136.44 180 bottom
PCV08  0.22U_0402_16V7K  [C_0402]  78.39 132.28 270 top
PCV09  680P_0603_50V7K  [C_0603]  92.42 131.71 0 top
PCV10  0.1U_0402_25V6K  [C_0402]  69.57 130.15 90 top
PCV11  1U_0603_10V6K  [C_0603]  80.74 129.73 0 top
PCV12  1U_0603_10V6K  [C_0603]  80.74 131 0 top
PCV13  10U_0603_25V6M  [C_0603]  81.95 124.9 90 bottom
PCV14  10U_0603_25V6M  [C_0603]  81.95 124.9 90 top
PCV15  4.7U_0603_25V6K  [C_0603]  83.28 124.9 90 bottom
PCV16  2200P_0402_50V7K  [C_0402]  82.32 122.65 180 top
PCV17  0.1U_0402_25V6  [C_0402]  82.32 123.54 180 top
PCV18  2200P_0402_50V7K  [C_0402]  82.32 122.65 180 bottom
PCV19  0.1U_0402_25V6  [C_0402]  82.32 123.54 180 bottom
PCV20  1000P_0402_50V7K  [C_0402]  67.23 128.39 180 top
PCV21  0.22U_0402_16V7K  [C_0402]  79.68 128.33 180 top
PCV22  0.22U_0402_10V6K  [C_0402]  67.92 126.69 270 top
PCV23  0.22U_0402_10V6K  [C_0402]  70.66 125.79 180 top
PCV24  680P_0603_50V7K  [C_0603]  92.45 128.16 0 top
PCV25  1000P_0402_50V7K  [C_0402]  74.66 125.34 180 top
PCV26  180P_0402_50V8J  [C_0402]  73.68 122.8 0 top
PCV27  330P_0402_50V7K  [C_0402]  75.4 124.39 0 top
PCV28  0.033U_0402_16V7K  [C_0402]  70.96 123.49 90 top
PCV29  390P_0402_50V7K  [C_0402]  75.41 121.08 90 top
PCV30  0.15U_0402_16V7K  [C_0402]  69.21 122.99 180 top
PCV31  330P_0402_50V  [C_0402]  72.82 121.03 180 top
PCV32  0.1U_0402_25V6  [C_0402]  69.21 124.19 180 top
PCV33  820PF_0402_50V7K  [C_0402]  71.78 125.34 0 top
PCV34  0.01U_0402_50V7K  [C_0402]  76.44 125.34 180 top
PCV35  4.7U_0603_25V6K  [C_0603]  83.56 134.78 270 bottom
PCV36  4.7U_0603_25V6K  [C_0603]  83.28 124.9 90 top
PCV171  560U_D2_2VM_R4.5M  [C_D2]  102.9 136.16 90 bottom
PCV172  560U_D2_2VM_R4.5M  [C_D2]  102.9 124.54 270 bottom
PCW01  0.1U_0402_25V6  [C_0402]  137.45 108.21 270 bottom
PCW02  2200P_0402_50V7K  [C_0402]  135.42 108.21 270 bottom
PCW03  10U_0603_25V6M  [C_0603]  139.67 108.9 270 top
PCW04  10U_0603_25V6M  [C_0603]  139.67 108.9 270 bottom
PCW05  22U_0603_6.3V6M  [C_0603]  154.22 111.67 90 top
PCW06  22U_0603_6.3V6M  [C_0603]  154.31 109.23 270 top
PCW07  22U_0603_6.3V6M  [C_0603]  154.22 111.67 90 bottom
PCW08  22U_0603_6.3V6M  [C_0603]  154.31 109.23 270 bottom
PCW09  0.1U_0402_25V6  [C_0402]  138.44 111.34 90 bottom
PCW10  1U_0402_10V6K  [C_0402]  142.66 111.39 180 bottom
PCW11  1U_0402_10V6K  [C_0402]  144.29 111.43 90 bottom
PCW12  0.1U_0402_10V6K  [C_0402]  147.13 108.23 0 top
PCW13  680P_0603_50V7K  [C_0603]  149.8 111.27 90 top
PCW14  330P_0402_50V7K  [C_0402]  147.06 113.74 90 bottom
PCW15  1000P_0402_50V7K  [C_0402]  136.43 108.21 270 bottom
PCW16  1000P_0402_50V7K  [C_0402]  134.4 108.21 270 bottom
PCW17  22U_0603_6.3V6M  [C_0603]  156.75 109.24 270 top
PCW18  22U_0603_6.3V6M  [C_0603]  155.55 109.24 270 top
PCW19  22U_0603_6.3V6M  [C_0603]  155.55 109.24 270 bottom
PCW20  22U_0603_6.3V6M  [C_0603]  156.75 109.24 270 bottom
PCZ01  8200P_0402_25V7K  [C_0402]  180.44 55.85 0 top
PCZ02  2200P_0402_50V7K  [C_0402]  182.27 56.13 0 bottom
PCZ03  15P_0402_50V8J  [C_0402]  180.44 56.73 0 top
PCZ04  1000P_0402_50V7K  [C_0402]  181.21 53.61 180 bottom
PCZ05  1000P_0402_50V7K  [C_0402]  179.02 56.24 180 top
PCZ06  1000P_0402_50V7K  [C_0402]  182.08 53.55 90 bottom
PCZ07  2200P_0402_25V7K  [C_0402]  181.41 55.39 180 bottom
PCZ08  0.01U_0402_25V7K  [C_0402]  180.51 56.39 90 bottom
PCZ09  2200P_0402_25V7K  [C_0402]  181.4 56.39 90 bottom
PCZ10  1000P_0402_50V7K  [C_0402]  180.42 52.64 0 top
PCZ11  3300P_0402_25V7K  [C_0402]  181.34 51.75 180 top
PCZ12  470P_0402_50V7K  [C_0402]  179.02 58.02 180 top
PCZ13  470P_0402_50V7K  [C_0402]  178.3 48.64 90 bottom
PCZ14  470P_0402_50V7K  [C_0402]  176.58 52.29 90 top
PCZ15  15P_0402_50V8J  [C_0402]  178.3 51.07 180 top
PCZ16  2200P_0402_50V7K  [C_0402]  177.4 49.28 90 top
PCZ17  1000P_0402_50V7K  [C_0402]  176.29 50.46 180 bottom
PCZ18  1000P_0402_50V7K  [C_0402]  176.29 49.57 180 bottom
PCZ19  0.1U_0402_25V6  [C_0402]  174.64 52.32 90 top
PCZ20  0.1U_0402_25V6  [C_0402]  173.69 50.46 180 top
PCZ21  0.1U_0402_25V6  [C_0402]  174.39 50.46 180 bottom
PCZ22  1000P_0402_50V7K  [C_0402]  173.69 52.32 90 top
PCZ23  0.01U_0402_50V7K  [C_0402]  172.63 49.36 270 bottom
PCZ24  0.1U_0402_25V6  [C_0402]  178.79 61.07 90 top
PCZ25  470P_0402_50V7K  [C_0402]  175.99 59.44 270 top
PCZ26  0.022U_0402_16V7K  [C_0402]  174.56 61.9 180 top
PCZ27  0.01UF_0402_25V7K  [C_0402]  174.35 61.24 180 bottom
PCZ28  3300P_0402_50V7-K  [C_0402]  171.53 65.59 0 top
PCZ29  1000P_0402_50V7K  [C_0402]  172.45 63.81 180 top
PCZ30  15P_0402_50V8J  [C_0402]  172.61 61.24 180 bottom
PCZ31  2200P_0402_50V7K  [C_0402]  172.65 62.12 90 bottom
PCZ32  1000P_0402_50V7K  [C_0402]  175.1 59.44 270 top
PCZ33  2200P_0402_50V7K  [C_0402]  173.47 62.92 90 top
PCZ34  1U_0603_10V6K  [C_0603]  171.93 51.24 180 bottom
PCZ35  1000P_0402_50V7K  [C_0402]  171.53 61.27 0 top
PCZ36  1000P_0402_50V7K  [C_0402]  171.79 58.22 0 top
PD1  -  [TVNST52302AB0_SOT523-3]  58.52 132.33 270 top
PD2  -  [BAV99W_SC70-3]  51.09 129.88 180 top
PD3  -  [BAV99W_SC70-3]  51.09 134.59 0 top
PD5  L03ESDL5V0CG3-2  SOT523  [TVNST52302AB0_SOT523-3]  162.09 37.2 180 top
PD6  L03ESDL5V0CG3-2  SOT523  [TVNST52302AB0_SOT523-3]  167.42 41.02 0 top
PD14  AZ4024-02S_SOT23  [PJSOT24C_SOT23-3]  181.75 43.62 270 top
PD501  -  [RB751V-40_SOD323-2]  25.31 84.46 90 bottom
PDB01  -  [LRB715FT1G_SOT323-3]  198.6 49.72 270 top
PDB13  AZ4024-02S_SOT23  [PJSOT24C_SOT23-3]  181.75 47.62 270 top
PDM01  -  [RB751V-40_SOD323-2]  36.48 25.26 270 top
PHV01  470K_0402_5%_TSM0B474J4702RE  [R_0402]  88.5 120.78 0 bottom
PHV02  10K_0402_5%_ERTJ0ER103J  [R_0402]  94.2 119.85 135 bottom
PHZ01  100K_0402_1%_B25/50 4250K  [R_0402]  156.13 50.41 180 bottom
PHZ02  220K_0402_5%_B25/50 4700K  [R_0402]  160.64 69.21 180 bottom
PHZ03  100K_0402_1%_B25/50 4250K  [R_0402]  158.07 98.15 180 bottom
PHZ04  100K_0402_1%_B25/50 4250K  [R_0402]  170.98 52.9 270 top
PHZ05  100K_0402_1%_B25/50 4250K  [R_0402]  157.2 96.67 0 bottom
PJP1  JUMP_43X79  [JUMP_43X79-NPM]  85.27 144.14 90 top
PJP2  -  [JUMP_43X79]  74.03 144.76 90 top
PJP3  JUMP_43X79  [JUMP_43X79-NPM]  178.02 39.9 270 bottom
PJP301  -  [JUMP_43X39]  20.46 37.73 90 bottom
PJP302  -  [JUMP_43X118]  28.49 56.35 0 bottom
PJP501  -  [JUMP_43X79]  28.04 102.84 270 bottom
PJP502  -  [JUMP_43X79]  27.21 109.11 90 top
PJP503  -  [JUMP_43X79]  27.21 109.14 90 bottom
PJP1801  -  [JUMP_43X39]  206.47 55.57 270 top
PJP1802  -  [JUMP_43X79]  194.26 60.76 180 bottom
PJP2501  -  [JUMP_43X39]  75.61 114.93 270 top
PJP2502  -  [JUMP_43X39]  60.85 112.2 180 top
PJPA01  -  [JUMP_43X39]  167.92 55.58 180 bottom
PJPB01  JUMP_43X118  [JUMP_43X118-NPM]  191.52 49.03 270 bottom
PJPDC1  ACES_50458-00601-001  [ACES_50458-00601-001_6P-T]  75.2 143.96 0 bottom
PJPG01  JUMP_43X79  [JUMP_43X79-NPM]  160.76 101.71 270 bottom
PJPH01  -  [JUMP_43X39]  164.83 48.64 180 top
PJPH02  -  [JUMP_43X118]  150.89 46.6 180 top
PJPI01  JUMP_43X79  [JUMP_43X79-NPM]  170.92 79.75 135 bottom
PJPM01  -  [JUMP_43X39]  51.05 25.12 90 top
PJPM02  -  [JUMP_43X118]  44.8 31.69 90 bottom
PJPM03  -  [JUMP_43X39]  39.85 35.03 90 top
PJPV01  JUMP_43X79  [JUMP_43X79-NPM]  88.65 140.25 180 bottom
PJPW01  -  [JUMP_43X39]  133.93 111.2 270 bottom
PJPW02  -  [JUMP_43X118]  157.52 111.65 90 bottom
PL1  5A Z150 20M 1210_2P  [5A_Z150_1210_2P]  85.27 143.33 90 top
PL2  5A Z150 20M 1210_2P  [5A_Z150_1210_2P-NPM]  74.03 143.96 90 top
PL3  BLM15AG102SN1D_2P  [MURAT_BLM15AG102SN1D_2P]  56.1 133.9 270 top
PL4  5A Z150 20M 1210_2P  [5A_Z150_1210_2P]  178.02 40.7 270 bottom
PL301  1.5UH_9A_20%_7X7X3_M  [L_7X7X3_M_2P]  26.1 43.87 90 bottom
PL311  5A_Z120_25M_0805_2P  [TAI-T_HCB2012KF-121T50_2P-NPM]  18.44 37.4 90 bottom
PL501  1.5UH_9A_20%_7X7X3_M  [L_7X7X3_M_2P]  19.34 98.82 90 bottom
PL511  5A Z150 20M 1210_2P  [5A_Z150_1210_2P-NPM]  28.04 103.64 270 bottom
PL1801  1UH_6.6A_20%_5X5X3_M  [L_5X5X3_M_2P]  197.5 53.68 90 bottom
PL1811  5A_Z120_25M_0805_2P  [TAI-T_HCB2012KF-121T50_2P-NPM]  206.45 55.95 270 bottom
PLA01  0.47UH_NA__12.2A_20%  [L_5X5X3_M]  158.89 53.79 180 bottom
PLB01  4.7UH_5.5A_20%_7X7X3_M  [L_7X7X3_M_2P]  187.91 41.65 180 bottom
PLB02  -  [5A_Z80_0805_2P]  191.52 49.39 270 bottom
PLG01  0.15UH_NA__36A_20%  [L_7X7X4_M]  152.69 91.94 90 bottom
PLG11  5A Z150 20M 1210_2P  [5A_Z150_1210_2P]  160.76 102.51 270 bottom
PLH01  1UH_11A_20%_7X7X3_M  [L_7X7X3_M_2P]  157.45 45.47 180 bottom
PLH11  5A_Z120_25M_0805_2P  [TAI-T_HCB2012KF-121T50_2P-NPM]  165.22 48.17 180 bottom
PLI01  0.15UH_NA__36A_20%  [L_7X7X4_M]  156.85 61.47 90 bottom
PLI02  0.15UH_NA__36A_20%  [L_7X7X4_M]  157.61 87.84 270 bottom
PLI11  5A Z150 20M 1210_2P  [5A_Z150_1210_2P]  171.48 79.18 135 bottom
PLM01  1UH_11A_20%_7X7X3_M  [L_7X7X3_M_2P]  54.73 27.6 180 bottom
PLM11  5A_Z120_25M_0805_2P  [TAI-T_HCB2012KF-121T50_2P-NPM]  49.01 24.57 90 top
PLV01  0.22UH_24A_20%_7X7X4_MOLDING  [L_7X7X4_M]  97.21 122.95 135 bottom
PLV02  0.22UH_24A_20%_7X7X4_MOLDING  [L_7X7X4_M]  97.39 137.94 225 bottom
PLV11  5A Z150 20M 1210_2P  [5A_Z150_1210_2P]  89.44 140.21 180 bottom
PLW01  1UH_6.6A_20%_5X5X3_M  [L_5X5X3_M_2P]  147.39 110.16 0 bottom
PLW11  5A_Z120_25M_0805_2P  [TAI-T_HCB2012KF-121T50_2P-NPM]  136.09 111.75 270 bottom
PQ1  -  [FDV301N-G_SOT23-3]  54.64 132.34 180 top
PQ2  -  [MMST3904-7-F_SOT323-3]  53.06 134.81 270 top
PQ11  2N7002KW_SOT323-3  [DMN65D8LW-7_SOT323-3]  166.15 35.94 270 top
PQ12  L2N7002DW1T1G  SC88-6  [DMN65D8LDW-7_SOT363-6]  168.83 36 180 top
PQ13  2N7002KDW_SOT363-6  [DMN65D8LDW-7_SOT363-6]  209.52 49.73 270 top
PQA01  -  [AONH36334_DFN3X3A8-10]  161.49 55.55 0 bottom
PQB11  -  [EMB04N03H_EDFN5X6-8-5]  190.66 56.19 90 top
PQB12  -  [EMB04N03H_EDFN5X6-8-5]  190.66 54.04 180 top
PQB13  -  [EMB04N03H_EDFN5X6-8-5]  182.15 46.54 90 bottom
PQB25  AON7506_DFN33-8-5  [AON7702L_DFN8-5]  193.61 41.89 270 bottom
PQB26  AON7408L_DFN8-5  [AON7702L_DFN8-5]  190.62 43.77 90 bottom
PQB28  -  [LMUN5113T1G_SOT323-3]  174.73 35.43 270 top
PQB29  -  [LTC015EUBFS8TL_UMT3F]  178.05 34.35 90 top
PQB30  2N7002KW_SOT323-3  [DMN65D8LW-7_SOT323-3]  194.03 60.39 180 top
PQB31  2N7002KW_SOT323-3  [DMN65D8LW-7_SOT323-3]  201.01 46.99 270 top
PQB32  -  [RUM002N02GT2L_VMT3]  204.25 50.54 180 top
PQB33  -  [RUM002N02GT2L_VMT3]  205.96 51.69 0 top
PQM01  -  [AONH36334_DFN3X3A8-10]  44.08 28.47 0 bottom
PQV01  -  [AON6994_DFN5X6D-8-7]  85.17 122.38 0 top
PQV02  -  [AON6994_DFN5X6D-8-7]  88.98 122.38 180 bottom
PQV03  -  [AON6994_DFN5X6D-8-7]  89.03 137.5 180 top
PQV04  -  [AON6994_DFN5X6D-8-7]  85.22 137.5 0 bottom
PR1  33_0402_5%  [R_0402]  55.62 128.58 180 top
PR3  100K_0402_1%  [R_0402]  56.98 133.79 0 top
PR4  10K_0402_1%  [R_0402]  52.74 132.98 90 top
PR5  2.2K_0402_5%  [R_0402]  53.97 128.58 180 top
PR6  15K_0402_1%  [R_0402]  57.9 134.62 180 top
PR7  100_0402_5%  [R_0402]  51.91 135.77 270 top
PR31  0_0402_5%  [R_0402]  207.43 47.42 90 top
PR32  3.3K_1206_5%  [R_1206]  211.36 51.62 180 top
PR33  10K_0402_1%  [R_0402]  171.1 34.93 270 top
PR34  1M_0402_1%  [R_0402]  212.44 50.68 270 top
PR35  0_0402_5%  [R_0402]  207.74 49.98 270 top
PR36  1M_0402_1%  [R_0402]  164.68 34.22 0 top
PR37  100_0402_5%  [R_0402]  162.98 40.52 270 top
PR38  1M_0402_1%  [R_0402]  212.44 49.03 270 top
PR39  200_0402_5%  [R_0402]  165.01 40.52 270 top
PR40  100K_0402_1%  [R_0402]  170.21 35.8 90 top
PR41  10K_0402_1%  [R_0402]  165.9 39.61 90 top
PR42  100_0402_5%  [R_0402]  161.07 40.52 270 top
PR43  100K_0402_1%  [R_0402]  164.12 37.77 90 top
PR44  1M_0402_1%  [R_0402]  166.47 34.02 90 top
PR45  1M_0402_1%  [R_0402]  208.5 49.07 90 top
PR301  0_0603_5%  [R0603_0OHM]  20.98 39.99 0 bottom
PR302  499K_0402_1%  [R_0402]  18.16 46.09 90 bottom
PR303  150K_0402_1%  [R_0402]  19.01 46.07 90 bottom
PR304  10K_0402_1%  [R_0402]  20.05 44.7 180 top
PR305  4.7_1206_5%  [R_1206]  26.62 43.85 180 top
PR306  1K_0402_5%  [R_0402]  21.52 47.86 180 bottom
PR307  150K_0402_1%  [R_0402]  20.66 46.99 270 bottom
PR308  150K_0402_1%  [R_0402]  19.78 46.08 90 bottom
PR501  0_0603_5%  [R0603_0OHM]  23.76 100.15 90 bottom
PR502  0_0402_5%  [R0402_0OHM]  21.41 86 0 bottom
PR503  0_0402_5%  [R0402_0OHM]  26.49 94.08 270 bottom
PR504  10K_0402_1%  [R_0402]  29.28 92.31 90 bottom
PR505  4.7_1206_5%  [R_1206]  20.75 99.48 90 top
PR506  2.2K_0402_5%  [R_0402]  21.41 86.77 0 bottom
PR507  0_0402_5%  [R0402_0OHM]  27.12 83.36 90 bottom
PR508  1M_0402_5%  [R_0402]  26.6 91.5 180 bottom
PR509  1K_0402_5%  [R_0402]  23.97 92.31 90 bottom
PR510  150K_0402_1%  [R_0402]  23.96 94.04 0 bottom
PR511  150K_0402_1%  [R_0402]  25.69 94.06 270 bottom
PR1801  0_0402_5%  [R_0402]  202.87 58.73 180 bottom
PR1802  1M_0402_5%  [R_0402]  201.89 57.91 0 bottom
PR1803  100K_0402_5%  [R_0402]  200.95 58.75 270 bottom
PR1804  4.7_1206_5%  [R_1206]  198.47 53.72 0 top
PR1805  10K_0402_1%  [R_0402]  203.68 57.01 90 bottom
PR1807  20K_0402_1%  [R_0402]  205.33 57.92 270 bottom
PR2501  22K_0402_1%  [R_0402]  73.31 110.7 270 top
PR2502  21.5K_0402_1%  [R_0402]  63.85 112.42 270 top
PR2503  10K_0402_1%  [R_0402]  65.62 109.15 0 top
PR2504  2.2_0402_1%  [R_0402]  70.32 115.37 0 top
PR2505  10K_0402_1%  [R_0402]  68.92 108.26 0 top
PRA01  2.2_0603_5%  [R_0603]  168.27 55.04 180 top
PRA02  4.7_1206_5%  [R_1206]  159.42 53.97 0 top
PRA03  0.01_1206_1%  [R_1206_4P-D-NPM]  164.99 57.97 0 bottom
PRB01  0.01_1206_1%  [R_1206_4P-D]  178.86 44.76 180 bottom
PRB02  0.01_1206_1%  [R_1206_4P-D]  190.92 54.3 270 bottom
PRB03  3M_0402_5%  [R_0402]  193.76 63.37 0 top
PRB04  1M_0402_1%  [R_0402]  195.41 63.37 0 top
PRB06  0_0402_5%  [R0402_0OHM]  192.17 60 0 top
PRB07  4.02K_0402_1%  [R_0402]  193.96 58.62 270 top
PRB08  4.02K_0402_1%  [R_0402]  192.17 57.72 0 top
PRB09  374K_0402_1%  [R_0402]  201.38 47.94 0 top
PRB10  52.3K_0402_1%  [R_0402]  202.4 46.16 0 top
PRB11  1_0402_1%  [R_0402]  198.9 47.75 0 bottom
PRB12  2_0402_5%  [R_0402]  198.9 46.99 0 bottom
PRB13  100K_0402_5%  [R_0402]  203.18 44.89 180 top
PRB14  0_0603_5%  [R0603_0OHM]  200.31 45.02 180 bottom
PRB15  10_0805_1%  [R_0805]  198.73 50.41 0 bottom
PRB16  75K_0402_1%  [R_0402]  204.12 49.51 90 bottom
PRB17  150K_0402_1%  [R_0402]  203.36 50.43 270 bottom
PRB18  200K_0402_1%  [R_0402]  204.89 49.51 90 bottom
PRB19  0_0402_5%  [R0402_0OHM]  205.65 50.43 270 bottom
PRB20  0_0402_5%  [R0402_0OHM]  206.41 50.43 270 bottom
PRB21  0_0402_5%  [R_0402]  204.36 49.65 0 top
PRB22  0_0402_5%  [R0402_0OHM]  206.03 48.9 270 top
PRB23  100K_0402_1%  [R_0402]  208.7 49.51 90 bottom
PRB24  100K_0402_1%  [R_0402]  209.46 49.51 90 bottom
PRB25  499K_0402_1%  [R_0402]  204.36 48.06 0 top
PRB26  768K_0402_1%  [R_0402]  206.04 47.18 180 top
PRB27  200K_0402_1%  [R_0402]  201.14 40.94 90 bottom
PRB28  100K_0402_1%  [R_0402]  199.35 41.84 0 bottom
PRB29  0_0402_5%  [R0402_0OHM]  209.66 47.11 180 bottom
PRB30  100_0402_5%  [R_0402]  208.75 45.33 0 bottom
PRB31  1K_0402_1%  [R_0402]  208.75 45.33 0 top
PRB32  0_0402_5%  [R0402_0OHM]  210.47 46.24 270 top
PRB33  0_0402_5%  [R0402_0OHM]  208.75 44.51 0 top
PRB34  10.5K_0402_1%  [R_0402]  207.37 45.21 180 top
PRB35  100_0402_5%  [R_0402]  209.66 44.57 180 bottom
PRB36  2_0402_5%  [R_0402]  208.81 42.73 0 bottom
PRB37  0_0402_5%  [R0402_0OHM]  208.81 43.62 0 bottom
PRB38  22.6K_0402_1%  [R_0402]  204 43.42 90 top
PRB39  4.7_0402_5%  [R_0402]  201.9 41.85 270 bottom
PRB40  4.7_1206_5%  [R_1206]  190.34 43.81 270 top
PRB41  0_0603_5%  [R_0603]  176.63 37.27 180 top
PRB42  10K_0402_5%  [R_0402]  204.89 54.36 270 top
PRB43  160K_0402_1%  [R_0402]  205.6 52.57 180 top
PRB44  10K_0402_5%  [R_0402]  204.36 48.89 0 top
PRB45  100K_0402_1%  [R_0402]  198.03 47.63 270 top
PRG01  4.7_0603_1%  [R_0603]  160.14 96.5 90 bottom
PRG02  2_0402_1%  [R_0402]  157.79 95.16 0 top
PRG03  4.7_1206_5%  [R_1206]  152.12 91.62 0 top
PRG04  0.01_1206_1%  [R_1206_4P-D-NPM]  163.14 96.55 135 top
PRH01  0_0402_5%  [R_0402]  166.02 44.37 90 top
PRH02  1M_0402_1%  [R_0402]  165.26 45.28 270 top
PRH03  0_0402_5%  [R0402_0OHM]  165.34 42.03 180 top
PRH04  0_0402_5%  [R_0402]  164.42 42.79 0 top
PRH05  100K_0402_5%  [R_0402]  166.16 46.67 180 bottom
PRH06  10_0402_1%  [R_0402]  162.92 41.97 180 bottom
PRH07  4.7_1206_5%  [R_1206]  156.88 46.73 270 top
PRH08  7.5K_0402_1%  [R_0402]  165.77 43.54 90 bottom
PRH09  10K_0402_1%  [R_0402]  166.53 43.54 90 bottom
PRH11  2.2_0402_1%  [R_0402]  165.08 41.91 180 bottom
PRH12  1K_0402_1%  [R_0402]  165.01 44.46 270 bottom
PRI01  4.7_0603_1%  [R_0603]  163.99 67.94 90 bottom
PRI02  2_0402_1%  [R_0402]  161.36 65.55 90 top
PRI03  4.7_1206_5%  [R_1206]  156.9 61.27 0 top
PRI21  4.7_0603_1%  [R_0603]  168.32 86.04 0 bottom
PRI22  2_0402_1%  [R_0402]  168.23 88.22 0 bottom
PRI23  4.7_1206_5%  [R_1206]  157.58 87.98 0 top
PRI24  0.01_1206_1%  [R_1206_4P-D-NPM]  169.42 78.2 315 top
PRM01  4.7_1206_5%  [R_1206]  49.04 29.4 0 top
PRM02  2.2_0603_5%  [R_0603]  39.85 30.34 0 top
PRM03  8.2K_0402_5%  [R_0402]  37.82 25.08 270 top
PRM04  5.1_0603_5%  [R_0603]  32.76 23.91 90 top
PRM05  2.2_0603_5%  [R_0603]  33.95 25.3 270 top
PRM06  10K_0402_1%  [R_0402]  32.72 26.66 0 top
PRM07  453K_0402_1%  [R_0402]  32.8 27.47 0 top
PRM08  0_0402_5%  [R_0402]  32.8 28.28 0 top
PRM09  0_0402_5%  [R_0402]  32.73 30.92 0 top
PRM10  6.04K_0402_1%  [R_0402]  34.04 33.13 0 top
PRM11  10K_0402_1%  [R_0402]  33.18 32.2 90 top
PRM12  0.01_1206_1%  [R_1206_4P-D-NPM]  53.76 24.05 90 top
PRV01  0_0603_5%  [R0603_0OHM]  77.12 133.79 0 top
PRV02  32.4K_0402_1%  [R_0402]  73.19 133.73 90 top
PRV03  10K_0402_1%  [R_0402]  67.22 120.79 0 top
PRV04  10K_0402_1%  [R_0402]  73.96 133.73 90 top
PRV05  10K_0402_1%  [R_0402]  74.74 133.73 90 top
PRV06  4.7_1206_5%  [R_1206]  90.92 134.44 270 top
PRV07  3.65K_0603_1%  [R_0603]  66.96 121.79 0 top
PRV08  1_0402_1%  [R_0402]  66.89 123.71 270 top
PRV09  100K_0402_1%  [R_0402]  69.95 132.33 180 top
PRV10  100K_0402_1%  [R_0402]  71.79 133.71 90 top
PRV12  0_0402_5%  [R_0402]  67.84 131.06 0 top
PRV13  1_0603_5%  [R_0603]  79.6 131.06 270 top
PRV14  0_0402_5%  [R_0402]  67.84 130.23 0 top
PRV15  0_0402_5%  [R0402_0OHM]  68.73 129.34 0 top
PRV16  133K_0402_1%  [R_0402]  67.23 129.28 180 top
PRV17  100K_0402_1%  [R_0402]  79.49 124.26 180 top
PRV18  150K_0402_1%  [R_0402]  66.2 125.78 90 top
PRV19  13.3K_0402_1%  [R_0402]  67.03 126.69 270 top
PRV20  0_0402_5%  [R0402_0OHM]  78.57 122.61 0 top
PRV21  0_0603_5%  [R0603_0OHM]  78.39 127.25 0 top
PRV22  10K_0402_1%  [R_0402]  70.25 120.25 270 top
PRV23  4.7_1206_5%  [R_1206]  90.97 125.45 90 top
PRV24  3.65K_0603_1%  [R_0603]  68.08 118.46 90 top
PRV25  1_0402_1%  [R_0402]  71.8 121.95 90 top
PRV26  301_0402_1%  [R_0402]  73.76 124.53 270 top
PRV27  121K_0402_1%  [R_0402]  77.3 122.28 180 top
PRV28  2.61K_0402_1%  [R_0402]  70.39 122.03 270 top
PRV29  1.37K_0402_1%  [R_0402]  74.58 124.53 270 top
PRV30  11K_0402_1%  [R_0402]  70.07 123.49 90 top
PRV31  22.1K_0402_1%  [R_0402]  74.57 121.99 270 top
PRV32  2K_0402_1%  [R_0402]  73.69 121.99 270 top
PRV33  665_0402_1%  [R_0402]  72.68 123.62 90 top
PRV34  0_0402_5%  [R0402_0OHM]  76.31 123.57 180 top
PRV35  100_0402_1%  [R_0402]  71.85 123.62 90 top
PRV36  0_0402_5%  [R0402_0OHM]  77.57 124.44 90 top
PRV37  0_0402_5%  [R0402_0OHM]  78.59 123.46 0 top
PRW01  0_0402_5%  [R_0402]  140.06 112.25 270 bottom
PRW02  1M_0402_1%  [R_0402]  139.28 111.34 90 bottom
PRW03  0_0402_5%  [R_0402]  147.39 111.15 180 top
PRW04  0_0402_5%  [R_0402]  145.14 111.45 90 bottom
PRW05  100K_0402_5%  [R_0402]  140.95 112.25 270 bottom
PRW06  10_0402_1%  [R_0402]  144.81 108.13 0 top
PRW07  4.7_1206_5%  [R_1206]  147.78 109.77 0 top
PRW09  39.2K_0402_1%  [R_0402]  143.46 111.49 90 bottom
PRW10  31.6K_0402_1%  [R_0402]  142.6 112.25 180 bottom
PRW11  2.2_0402_1%  [R_0402]  145.08 110.04 180 top
PRW13  1K_0402_1%  [R_0402]  146.04 114.4 225 bottom
PRZ01  1.5K_0402_1%  [R_0402]  182.16 55.82 90 top
PRZ03  0_0402_5%  [R0402_0OHM]  183.88 53.65 180 bottom
PRZ04  1.74K_0402_1%  [R_0402]  181.21 52.72 180 bottom
PRZ05  18.7K_0402_1%  [R_0402]  179.02 55.4 180 top
PRZ06  10_0402_5%  [R_0402]  183.18 55.3 180 bottom
PRZ07  0_0402_5%  [R0402_0OHM]  183.88 54.41 180 bottom
PRZ08  1K_0402_1%  [R_0402]  181.26 54.47 180 bottom
PRZ10  12K_0402_1%  [R_0402]  180.9 59.08 270 top
PRZ11  20K_0402_1%  [R_0402]  178.11 54.52 0 top
PRZ13  7.5K_0603_1%  [R_0603]  157.63 54.63 90 top
PRZ14  0_0402_5%  [R0402_0OHM]  181.34 53.53 180 top
PRZ15  57.6K_0402_1%  [R_0402]  179.02 57.13 180 top
PRZ16  10K_0402_1%  [R_0402]  180.76 58.52 180 bottom
PRZ18  0_0402_5%  [R0402_0OHM]  182.15 52.65 270 top
PRZ19  1K_0402_1%  [R_0402]  181.34 50.86 180 top
PRZ20  49.9_0402_1%  [R_0402]  179.19 49.56 270 bottom
PRZ21  619_0402_1%  [R_0402]  179.2 50.44 180 bottom
PRZ22  0_0402_5%  [R0402_0OHM]  179.84 59.3 0 bottom
PRZ23  26.7K_0402_1%  [R_0402]  177.45 52.32 90 top
PRZ24  4.75K_0402_1%  [R_0402]  178.37 50.22 270 top
PRZ25  100K_0603_1%  [R_0603]  176.33 48.98 90 top
PRZ26  165K_0402_1%  [R_0402]  174.87 48.68 0 bottom
PRZ27  75K_0402_1%  [R_0402]  176.52 48.68 0 bottom
PRZ28  7.32K_0402_1%  [R_0402]  177.17 49.56 90 bottom
PRZ29  100K_0603_1%  [R_0603]  175.12 48.98 90 top
PRZ30  10_0402_1%  [R_0402]  159.79 72.77 0 bottom
PRZ31  10_0402_1%  [R_0402]  160.99 68.08 0 bottom
PRZ32  10K_0402_1%  [R_0402]  173.69 49.64 180 top
PRZ33  10K_0402_1%  [R_0402]  174.39 49.57 180 bottom
PRZ34  0_0402_5%  [R0402_0OHM]  171.79 52.02 0 top
PRZ35  1K_0402_1%  [R_0402]  171.74 48.45 90 bottom
PRZ36  61.9K_0402_1%  [R_0402]  171.79 52.91 0 top
PRZ37  2.15K_0402_1%  [R_0402]  175.31 47.3 180 top
PRZ38  2.15K_0402_1%  [R_0402]  175.31 48.06 180 top
PRZ39  1K_0402_1%  [R_0402]  173.58 47.23 90 top
PRZ40  45.3_0402_1%  [R_0402]  177.96 61.07 90 top
PRZ41  110_0402_1%  [R_0402]  177.2 61.07 90 top
PRZ42  100_0402_1%  [R_0402]  176.44 61.07 90 top
PRZ43  110_0402_1%  [R_0402]  175.68 61.07 90 top
PRZ44  7.5K_0603_1%  [R_0603]  152.56 94.61 90 top
PRZ45  12K_0402_1%  [R_0402]  174.27 63.04 270 bottom
PRZ46  49.9_0402_1%  [R_0402]  177.49 60.7 90 bottom
PRZ47  0_0402_5%  [R0402_0OHM]  176.71 61.13 90 bottom
PRZ48  10_0402_1%  [R_0402]  175.92 61.13 90 bottom
PRZ49  100_0402_1%  [R_0402]  175.15 61.13 90 bottom
PRZ50  133K_0402_1%  [R_0402]  176.82 59.44 270 top
PRZ51  10_0402_5%  [R_0402]  173.5 63.03 270 bottom
PRZ52  1K_0402_1%  [R_0402]  171.53 66.48 0 top
PRZ53  0_0402_5%  [R0402_0OHM]  172.45 64.7 180 top
PRZ55  2K_0402_1%  [R_0402]  171.81 63.04 270 bottom
PRZ56  52.3K_0402_1%  [R_0402]  174.28 59.44 270 top
PRZ57  2_0402_1%  [R_0402]  171.03 50.22 0 bottom
PRZ58  4.32K_0402_1%  [R_0402]  172.37 63 270 top
PRZ59  0_0402_5%  [R0402_0OHM]  170.72 63.95 270 top
PRZ60  24K_0402_1%  [R_0402]  171.79 53.8 0 top
PRZ61  3.65K_0402_1%  [R_0402]  171.61 63 270 top
PRZ63  0_0402_5%  [R0402_0OHM]  171.79 59.11 0 top
PRZ64  24K_0402_1%  [R_0402]  171.1 53.22 270 bottom
PRZ65  61.9K_0402_1%  [R_0402]  173.52 59.44 270 top
PRZ66  51.1K_0402_1%  [R_0402]  171.79 54.69 0 top
PRZ67  97.6K_0402_1%  [R_0402]  171.79 55.58 0 top
PRZ68  19.1K_0402_1%  [R_0402]  171.79 56.47 0 top
PRZ69  35.7K_0402_1%  [R_0402]  171.79 57.36 0 top
PU301  -  [SY8286BRAC_QFN20_3X3]  20.79 41.49 90 bottom
PU501  SY8180CRAC_QFN20_3X3  [SY8288CRAC_QFN20_3X3]  24.66 98.72 270 bottom
PU1801  -  [RT8061AZQW_WDFN10_3X3]  201.35 53.89 90 bottom
PU2501  -  [RT9059GSP_SO8]  71.51 110.42 90 top
PUA01  -  [NCP81253MNTBG_DFN8_2X2]  169.17 53.85 270 bottom
PUB01  -  [ISL95522HRZ-T_TQFN32_4X4]  206.03 43.47 90 bottom
PUG01  -  [NCP302045MNTXG_PQFN33_5X5]  157.84 95.25 0 bottom
PUH01  -  [RT6228AGQUF_UQFN12_3X3]  161.92 43.27 90 bottom
PUI01  -  [NCP302045MNTXG_PQFN33_5X5]  162.02 66.45 0 bottom
PUI02  -  [NCP302045MNTXG_PQFN33_5X5]  166.87 87.52 270 bottom
PUM01  -  [RT8207PGQW_WQFN20_3X3]  37.65 30.36 180 top
PUV01  -  [ISL62771HRTZ-T_TQFN40_5X5]  71.63 131.5 0 top
PUW01  -  [RT6226AGQUF_UQFN12_3X3]  144.7 109.12 180 bottom
PUZ01  -  [NCP81218MNTXG_QFN48_6X6]  177.63 52.85 90 bottom
Q1  -  [2N7002K_SOT23-3]  61.38 30.44 180 top
Q2  -  [DDTA144VCA-7-F_SOT23-3]  18.68 126.93 90 bottom
Q3  -  [LN2306LT1G_SOT23-3]  23.38 130.87 90 bottom
Q4  -  [DDTA144VCA-7-F_SOT23-3]  18.68 130.87 90 bottom
Q5  NTK3139PT1G_SOT723-3  [2N7002K_SOT23-3]  110.04 27.74 270 bottom
Q6  -  [2N7002K_SOT23-3]  101.91 32.44 270 bottom
Q7  -  [LN2306LT1G_SOT23-3]  93.1 39.56 270 top
Q8  -  [LN2306LT1G_SOT23-3]  128.09 31.43 270 top
Q9  -  [LN2306LT1G_SOT23-3]  55.05 34.6 90 top
Q10  L2N7002DW1T1G_SC88-6  [DMN66D0LDW-7_SOT363-6]  118.08 29.54 270 top
Q11  L2N7002DW1T1G_SC88-6  [DMN66D0LDW-7_SOT363-6]  175.34 66.29 0 top
Q12  -  [DDTA144VCA-7-F_SOT23-3]  57.31 33.23 180 top
Q13  -  [LMBT3904LT1G_SOT23-3]  84.84 117.91 90 bottom
Q15  L2N7002DW1T1G_SC88-6  [DMN66D0LDW-7_SOT363-6]  28.29 130.85 90 bottom
Q16  L2N7002DW1T1G_SC88-6  [DMN66D0LDW-7_SOT363-6]  28.29 128.31 90 bottom
Q17  -  [LP2301ALT1G_SOT23-3]  64.42 35.39 180 top
Q18  2N7002KW 1N SOT323-3  [L2N7002WT1G_SC-70-3]  61.25 38.35 0 top
QA1  -  [LN2306LT1G_SOT23-3]  36.84 19.62 270 top
QC1  L2N7002DW1T1G_SC88-6  [DMN66D0LDW-7_SOT363-6]  126.12 39.78 90 bottom
QI1  -  [2N7002K_SOT23-3]  27.54 92.85 90 top
QI2  2N7002KW_SOT323-3  [DMN65D8LW-7_SOT323-3]  13.12 109.47 0 bottom
QI3  L2N7002DW1T1G_SC88-6  [DMN66D0LDW-7_SOT363-6]  27.94 89.34 270 bottom
QS1  L2N7002DW1T1G_SC88-6  [DMN66D0LDW-7_SOT363-6]  166.34 32.2 270 top
QT1  L2N7002DW1T1G_SC88-6  [DMN66D0LDW-7_SOT363-6]  23.34 115.36 90 top
QV1  L2N7002DW1T1G_SC88-6  [2N7002KDWH_SOT363-6]  123.66 120.85 0 top
R1  1K_0402_5%  [R_0402]  67.73 28.58 270 top
R2  10M_0402_5%  [R_0402]  67.73 29.32 90 top
R5  0_0402_5%  [R0402_0OHM]  223.12 31.94 180 bottom
R6  10K_0402_5%  [R_0402]  223.12 32.7 180 bottom
R8  0_0603_5%  [R_0603]  214.47 58.1 0 top
R10  0_0402_5%  [R_0402-NPM]  217.76 42.86 0 top
R11  0_0201_5%  [R_0201]  219.32 50.73 0 top
R12  0_0402_5%  [R_0402-NPM]  217.76 43.62 0 top
R13  0_0201_5%  [R0201_0OHM]  212.09 55.11 0 top
R14  33_0402_5%  [R_0402]  212.51 42.68 270 top
R15  10K_0402_5%  [R_0402]  221.26 57.34 0 top
R17  100K_0402_5%  [R_0402]  221.26 56.13 0 top
R18  0_0402_5%  [R_0402]  205.98 39.81 180 bottom
R19  0_0402_5%  [R_0402]  205.98 40.57 180 bottom
R25  100_0402_5%  [R_0402]  221.57 63.43 0 top
R26  10K_0402_5%  [R_0402]  27.09 129.4 90 bottom
R27  200_0402_5%  [R_0402]  15.96 130.87 0 bottom
R28  200_0402_5%  [R_0402]  15.96 126.93 0 bottom
R30  100K_0402_5%  [R_0402]  28.94 127.19 180 bottom
R31  100K_0402_5%  [R_0402]  29.68 127.19 0 bottom
R34  4.7K_0402_5%  [R_0402]  124.11 27.92 90 top
R35  4.7K_0402_5%  [R_0402]  124.88 27.92 90 top
R36  4.7K_0402_5%  [R_0402]  122.56 28.84 270 top
R37  4.7K_0402_5%  [R_0402]  116.16 29.65 0 top
R38  51K_0402_5%  [R_0402]  93.18 36 0 bottom
R39  100_0402_5%  [R_0402]  104.63 32.44 180 bottom
R40  100K_0402_5%  [R_0402]  92.44 36 180 bottom
R41  20K_0402_5%  [R_0402]  106.21 26.4 90 bottom
R42  10K_0402_5%  [R_0402]  131.86 30.46 90 top
R43  2.2K_0402_5%  [R_0402]  123.34 27.92 90 top
R45  2.2K_0402_5%  [R_0402]  115.29 28.06 0 top
R46  100K_0402_5%  [R_0402]  117.94 32.51 0 bottom
R47  100K_0402_5%  [R_0402]  51.22 35.06 270 top
R48  1K_0402_5%  [R_0402]  57.31 35.03 90 top
R49  2.2K_0402_5%  [R_0402]  176.2 65.21 180 top
R50  2.2K_0402_5%  [R_0402]  175.92 69.27 0 top
R52  6.49K +-1% 0402  [R_0402]  132.19 45.52 180 top
R53  0_0402_5%  [R0402_0OHM]  131.28 44.76 0 top
R54  18.7K_0402_1%  [R_0402]  176.63 66.8 225 bottom
R55  2K_0402_1%  [R_0402]  178.43 61.14 315 bottom
R57  0_0402_5%  [R_0402]  143.85 53.14 0 bottom
R58  0_0402_5%  [R_0402]  143.85 52.38 0 bottom
R59  0_0402_5%  [R_0402]  144.36 52.38 0 top
R60  0_0402_5%  [R_0402]  144.36 51.62 0 top
R61  0_0402_5%  [R_0402]  144.36 56.32 0 top
R62  0_0402_5%  [R_0402]  144.36 57.08 0 top
R63  10K_0402_5%  [R_0402]  64.37 38.67 180 top
R64  1M_0402_5%  [R_0402]  60.61 34.3 270 top
R65  100K_0402_5%  [R_0402]  59.85 34.3 270 top
R67  0_0603_5%  [R_0603]  215.38 35.8 90 top
R72  100K_0402_5%  [R_0402]  212.05 34.06 270 top
R75  100K_0402_5%  [R_0402]  217.64 50.73 0 top
R76  100K_0402_5%  [R_0402]  216.14 46.92 180 top
R77  100K_0402_5%  [R_0402]  215.25 54.92 180 top
R78  100_0402_5%  [R_0402]  215.22 46.16 0 top
R79  100_0402_5%  [R_0402]  216.57 47.93 90 top
R80  100_0402_5%  [R_0402]  222.55 54.1 180 top
R81  0_0603_5%  [R_0603]  213.7 32.36 90 top
R82  0_0603_5%  [R_0603]  214.92 32.36 90 top
R83  0_0402_5%  [R_0402]  212.73 45.56 90 top
R84  0_0201_5%  [R_0201]  206.75 41.21 0 top
R85  0_0201_5%  [R_0201]  206.75 40.44 0 top
R86  4.7K_0402_5%  [R_0402]  207.76 41.97 180 top
R87  4.7K_0402_5%  [R_0402]  207.76 39.68 180 top
R88  10K_0402_5%  [R_0402]  215.25 48.45 180 top
R89  100K_0402_5%  [R_0402]  31.99 131.38 180 bottom
R90  10K_0402_5%  [R_0402]  209.39 55.65 0 top
R91  10K_0402_5%  [R_0402]  220.96 36.51 180 bottom
R92  10K_0402_5%  [R_0402]  205.14 37.6 270 top
R95  S FUSE T0603FF1000TM 1A 65V UL FAST  [R_0603]  211.55 44.38 0 top
R96  0_0201_5%  [R_0201]  210.07 54.96 180 top
RA1  0_0805_5%  [R0805_0OHM]  37.97 7.17 180 top
RA2  0_0402_5%  [R0402_0OHM]  38.69 22.03 0 top
RA3  0_0603_5%  [R0603_0OHM]  26.83 21.52 270 top
RA4  33_0402_5%  [R_0402]  36.75 10.41 180 top
RA5  0_0402_5%  [R0402_0OHM]  37.96 22.03 180 top
RA6  0_0402_5%  [R0402_0OHM]  39.29 15.49 180 top
RA7  33_0402_5%  [R_0402]  36.43 13.65 180 top
RA8  33_0402_5%  [R_0402]  37.7 12.19 180 top
RA9  0_0402_5%  [R_0402]  30.51 20.43 90 top
RA10  0_0402_5%  [R_0402]  36.43 16.44 180 top
RA11  0_0402_5%  [R_0402]  29.69 20.43 90 top
RA12  100K_0402_5%  [R_0402]  35.42 9.14 180 top
RA13  100K_0402_5%  [R_0402]  26.12 16.82 0 top
RA14  200K_0402_1%  [R_0402]  32.91 19.74 0 top
RA15  100K_0402_5%  [R_0402]  33.74 17.97 0 top
RA16  0_0402_5%  [R_0402]  19.59 9.22 270 top
RA17  0_0402_5%  [R_0402]  26.96 8.01 270 top
RA18  0_0402_5%  [R_0402]  24.04 19.99 90 top
RA19  BLM15PD800SN1D_2P  [MURAT_BLM15PD600SN1D_2P]  23.01 1.65 180 top
RA20  BLM15PD800SN1D_2P  [MURAT_BLM15PD600SN1D_2P]  25.17 2.73 180 top
RA21  BLM15PD800SN1D_2P  [MURAT_BLM15PD600SN1D_2P]  28.09 5.65 180 top
RA22  BLM15PD800SN1D_2P  [MURAT_BLM15PD600SN1D_2P]  28.09 4.38 180 top
RA23  1K_0402_5%  [R_0402]  35.09 20.2 270 top
RA24  10K_0402_5%  [R_0402]  35.52 17.2 0 top
RA25  2.2K_0402_5%  [R_0402]  20.35 13.95 90 top
RA26  2.2K_0402_5%  [R_0402]  19.41 13.97 180 top
RA27  10_0402_1%  [R_0402]  24.87 14.03 180 top
RA28  1K_0402_5%  [R_0402]  23.96 14.85 0 top
RA29  4.7K_0402_5%  [R_0402]  21.8 13.77 0 top
RA30  10_0402_1%  [R_0402]  24.87 12.44 180 top
RA31  1K_0402_5%  [R_0402]  23.96 13.2 0 top
RA32  4.7K_0402_5%  [R_0402]  21.8 12 0 top
RA33  10K_0402_5%  [R_0402]  18.07 10.3 270 bottom
RA34  10K_0402_5%  [R_0402]  17.18 11.98 90 bottom
RA35  0_0201_5%  [R0201_0OHM]  16.09 15.55 0 top
RB1  0_0201_5%  [R_0201]  210.16 58.29 180 top
RB2  0_0201_5%  [R_0201]  215.93 57.16 270 top
RB3  0_0201_5%  [R_0201]  214.41 57.16 270 top
RB4  0_0201_5%  [R_0201]  165.52 67.93 90 top
RB5  0_0201_5%  [R_0201]  178.6 46.29 180 bottom
RB6  0_0201_5%  [R_0201]  175.55 46.29 0 bottom
RB7  0_0201_5%  [R_0201]  156.17 99.5 0 bottom
RB8  0_0201_5%  [R_0201]  184.1 31.55 180 top
RB9  0_0201_5%  [R_0201]  184.1 32.19 180 top
RB10  0_0201_5%  [R_0201]  55.53 26.27 90 top
RB11  0_0201_5%  [R_0201]  169.33 57.26 90 top
RB12  0_0201_5%  [R_0201]  169.33 58.17 270 bottom
RC1  1K_0402_5%  [R_0402]  142.1 81.34 180 bottom
RC2  1K_0402_5%  [R_0402]  139.68 64.07 180 bottom
RC3  49.9_0402_1%  [R_0402]  140.32 80.45 180 bottom
RC4  24.9_0402_1%  [R_0402]  131.49 74.76 180 top
RC5  10K_0402_5%  [R_0402]  109.05 53.27 0 bottom
RC6  10K_0402_5%  [R_0402]  108.67 50.73 0 bottom
RC7  2.2K_0402_5%  [R_0402]  145.27 53.91 180 top
RC8  2.2K_0402_5%  [R_0402]  145.27 53.14 180 top
