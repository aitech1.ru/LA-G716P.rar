# Allegro board LA-G716P r0.1.brd (continued)
## Routing (per net, layer and track width the routed paths; a pad name or vN(x,y) marks a point on that pad's centre or on a via; arc(x,y) is an arc through that point) (continued)
USB_EN#: length 248.2
  TOP w0.102: 42.17,66.73 42.15,66.75 UE1.13
  TOP w0.112: RE19.1 42.64,65.73 42.64,66.15 v2(42.32,66.47) 42.32,66.58 42.17,66.73 ; v2(206.8,37.67) 206.8,37.6 206.96,37.44 206.96,31.28 206.46,30.78 UU2.4 ; v2(45.29,46.03) 45.04,46.29 38.72,46.29 v1(36.53,44.1) 33.73,41.3 22.3,41.3 21.84,41.75 21.84,44.47 21.89,44.52 21.89,45.13 21.7,45.32 21.7,49.13 v2(21.37,49.46)
  IN2 w0.124: v2(206.8,37.67) 206.54,37.4 206.54,36.78 206.41,36.65 197.81,36.65 196.32,35.16 173.76,35.16 172.35,33.75 164.54,33.75 163.81,33.02 146.45,33.02 145.47,34 134.64,34 131.57,30.94 118.06,30.94 117.54,31.46 115.92,31.46 115.52,31.06 97.53,31.06 95.87,29.41 95.87,28.07 95.49,27.68 94.33,27.68 93.95,27.68 92.81,28.82 90.14,28.82 88.96,27.64 85.86,27.64 84.78,28.73 71.75,28.73 71.17,28.15 68.23,28.15 68.06,28.32 66.25,28.32 65.63,27.7 61.62,27.7 60.46,28.86 59.99,28.86 54.78,34.08 50.49,34.08 45.29,39.28 v2(45.29,46.03)
  BOTTOM w0.112: v2(21.37,49.46) 20.92,49.91 UU1.4 ; v2(45.29,46.03) 45.01,46.31 45.01,60.04 42.9,62.15 42.9,65.84 42.32,66.43 v2(42.32,66.47)
USB_OC0#: length 177.8
  TOP w0.112: v2(102.02,27.96) 103.15,26.83 125.8,26.83 125.88,26.9 v1(127.06,26.9) 129.59,26.9 130.68,28 v2(131.61,28) ; RC189.1 133,50.03 v2(133.42,50.45)
  IN3 w0.135: v2(142.85,38.57) 141.95,39.46 141.95,40.96 139.09,43.82 139.09,46.42 137.88,47.63 137.19,47.63 135.54,49.27 134.59,49.27 v2(133.42,50.45) ; v2(102.02,27.96) 100.09,26.03 68.36,26.03 67.66,26.73 61.36,26.73 58,30.09 57.3,30.09 55.63,31.77 48.59,31.77 48.23,32.12 48.23,33.14 46.64,34.73 42.44,34.73 39.62,37.55 39.62,41 35.34,45.28 35.34,48.18 28.21,55.3 23.53,55.3 22.51,54.29 22.51,52.13 22.2,51.82 v2(21.28,51.82)
  BOTTOM w0.102: UC1.CK6 133.2,50.66 v2(133.42,50.45)
  BOTTOM w0.112: v2(21.28,51.82) 20.92,52.17 UU1.3 ; v2(131.61,28) 130.46,28 129.96,27.49 129.96,25.33 130.59,24.7 136.33,24.7 136.55,24.92 136.55,26.22 136.81,26.47 136.81,29.14 139.23,31.55 139.23,35.14 142.65,38.57 v2(142.85,38.57)
USB_OC1#: length 89
  TOP w0.112: v2(167.93,42.35) 167.93,43.86 170.1,46.03 175.42,46.03 178.21,43.24 179.18,43.24 179.77,42.65 179.77,40.24 180.96,39.05 183.55,39.05 184.73,37.87 189.66,37.87 191.17,36.36 v1(191.17,34.51) 191.17,32.44 192.83,30.78 UU2.3 ; v2(134.08,50.45) 133.77,50.14 RC190.1
  IN2 w0.124: v2(167.93,42.35) 167.36,42.35 166.02,43.68 160.93,43.68 158.41,41.16 150.45,41.16 149.44,42.16 145.9,42.16 142.03,46.04 141.37,46.04 138.49,48.92 135.61,48.92 v2(134.08,50.45)
  BOTTOM w0.102: UC1.CK5 133.85,50.68 v2(134.08,50.45)
USB_OC2#: length 1.5
  TOP w0.112: v2(132.15,50.45) 132.24,50.35 RC191.1
  BOTTOM w0.102: v2(132.15,50.45) 131.9,50.69 UC1.CK8
USB_OC3#: length 179.2
  TOP w0.112: v2(131.49,50.45) 131.49,50.11 131.48,50.1 RC188.1 ; v2(36.23,101.4) v1(36.23,100.87)
  IN1 w0.089: 130.47,56.56 133.65,56.56 133.85,56.36 133.85,55.58 133.76,55.49 133.3,55.49 133.03,55.22 133.03,53.69 132.91,53.58 132,53.58 131.19,52.77 131.19,51.75 131.49,51.45 v2(131.49,50.45)
  IN1 w0.119: v2(36.23,101.4) 36.62,101.79 36.62,114.16 35.28,115.5 v2(34.91,115.5) ; 130.47,56.56 130.34,56.7 130.34,62.16 128.94,63.56 124.49,63.56 123.48,64.57 123.48,67.31 122.38,68.4 122.38,73.62 122.83,74.07 122.83,74.91 122.42,75.33 122.42,82.76 123.16,83.51 123.16,91.56 125.71,94.11 125.71,97.91 117.28,106.34 107.35,106.34 105.15,108.54 93.33,108.54 90.42,111.46 81.8,111.46 79.91,113.35 72.43,113.35 71.28,112.2 61.6,112.2 60.73,111.32 v2(60.73,110.94)
  IN3 w0.135: v2(36.23,101.4) 37.48,102.65 39.52,102.65 43.48,106.61 46.39,106.61 48.94,109.16 52.89,109.16 54.38,110.66 59.58,110.66 59.86,110.94 v2(60.73,110.94)
  BOTTOM w0.102: UC1.CK9 v2(131.49,50.45)
  BOTTOM w0.112: RT5.2 v2(34.91,115.5)
VCI_IN1#: length 6.2
  TOP w0.112: RE31.1 33.93,66.78 34.25,67.1 v1(34.25,68.18) 34.25,69.51 34.94,70.21 UE1.126
VCIN0_PH: length 121.6
  TOP w0.112: RH1.1 C32.1 C31.1 130.46,45.02 130.97,45.52 R52.2 131.28,46.34 v2(131.61,46.67) ; v2(48.55,62.8) 49.01,62.8 49.86,61.95 51.17,61.95 51.4,62.18 v1(51.4,62.48) 51.4,63.32 51.89,63.81 RE34.2
  IN2 w0.124: v2(48.55,62.8) 49.48,61.86 49.48,57.07 51.06,55.49 51.06,47.66 51.88,46.84 51.88,42.28 52.84,41.31 54.53,41.31 55.9,39.94 57.99,39.94 61.4,36.53 68.37,36.53 68.55,36.34 78.51,36.34 81.4,39.23 84.56,39.23 85.03,38.75 94.56,38.75 94.7,38.61 97.03,38.61 99.42,41 108.12,41 110.83,43.71 114.94,43.71 117.13,41.52 117.85,41.52 118.56,42.22 118.56,43.54 119.85,44.83 130.51,44.83 131.61,45.93 v2(131.61,46.67)
VCREF0: length 1.4
  TOP w0.112: RE35.2 46.62,64.5 CE19.1
VD_IN1_C: length 3.9
  TOP w0.112: RH1.2 C32.2 C31.2 131.42,43.67 v1(131.48,43.73) 131.48,44.56 R53.1
VGA_CBL_DET#: length 130.4
  TOP w0.112: JVGA1.7 218.22,35.75 218.98,36.51 v2(219.36,36.51)
  IN1 w0.119: v2(188.84,36.71) 188.84,37 188.73,37.12 182.44,37.12 176.82,31.5 176.82,31.19 175.21,29.58 173.53,29.58 172.3,30.82 166.12,30.82 164.9,32.05 161.82,32.05 160.94,31.17 160.18,31.17 159.55,31.81 v2(159.55,36.76) ; v2(121.63,39.76) 121.39,40 121.39,40.76 121.38,40.76 121.38,41.78 120.54,42.63 120.54,44.28 121.71,45.45 121.71,46.15 v2(121.7,46.16)
  IN2 w0.124: v2(159.55,36.76) 159.1,37.21 153.18,37.21 152.16,38.23 147.13,38.23 146.84,38.51 144.46,38.51 139.86,43.12 135.71,43.12 134.52,44.31 134.34,44.31 133.65,43.62 133.17,43.62 133.05,43.49 132.36,43.49 132.01,43.14 132.01,41.91 131.64,41.55 131.64,40.48 131.48,40.32 131.48,39.56 131.1,39.17 130.21,39.17 130.18,39.2 125.99,39.2 125.25,39.95 121.82,39.95 v2(121.63,39.76)
  IN3 w0.135: v2(219.36,36.51) 219,36.51 217.32,34.82 212.1,34.82 210.8,36.13 207.3,36.13 206.03,34.86 201.58,34.86 201.08,35.36 v2(197.39,35.36)
  BOTTOM w0.076: v2(121.7,46.16) 121.7,46.41 122.15,46.86 122.15,47.9 UC1.CR24
  BOTTOM w0.112: v2(197.39,35.36) 197.27,35.49 191.82,35.49 190.17,37.14 189.25,37.14 188.84,36.74 v2(188.84,36.71) ; R91.2 v2(219.36,36.51)
VGA_POK: length 28.2
  TOP w0.112: v2(60.64,126.91) v1(60.64,127.41)
  TOP w0.203: PUV01.9 69.27,128.3 v2(69.19,128.39)
  TOP w0.254: PRV37.2 79.51,123.46 v2(80.11,122.87) ; v2(60.64,126.91) RV166.2 RV165.1
  IN2 w0.254: v2(60.64,126.91) 60.92,127.19 66.07,127.19 67.28,128.39 v2(69.19,128.39)
  IN3 w0.254: v2(80.11,122.87) 77.57,125.41 72.17,125.41 v2(69.19,128.39)
VGA_SMB_CK3: length 7
  TOP w0.102: 123.01,122.19 v1(123.01,123.48) 123.15,123.62 123.15,124.74 122.83,125.06 122.83,125.36 122.83,125.36 122.83,125.37 v2(122.63,125.56)
  TOP w0.112: 123.01,122.19 123.01,122.16 122.97,122.12 122.97,121.58 123.66,120.89 QV1.1 123.66,120.77 123.48,120.59 RV6.2
  BOTTOM w0.102: v2(122.63,125.56) 122.87,125.8 UV1.U7
VGA_SMB_DA3: length 5.9
  TOP w0.102: 123.06,125.46 123.06,125.15 123.38,124.84 123.38,124.24 123.66,123.96 124.27,123.96 124.7,123.53 RV5.2 124.96,123.43
  TOP w0.112: 123.06,125.46 123.06,125.82 v2(122.63,126.24) ; QV1.4 124.96,123.43
  BOTTOM w0.102: UV1.U8 122.79,126.24 v2(122.63,126.24)
VIDALERT#: length 5.6
  BOTTOM w0.076: UC1.AA3 135.34,80.73 135.6,80.47 136.1,80.47 136.22,80.59 136.22,80.82 136.39,80.99 136.91,80.99 v1(138.42,79.48) 139.35,78.54 RC135.1
VIDALERT_N: length 49.1
  TOP w0.112: v2(176.97,62.68) 177.2,62.45 PRZ41.2
  IN1 w0.119: v2(142.92,77.78) 144.37,77.78 145.53,78.95 148.07,78.95 153.84,73.17 165.31,73.17 168.81,69.66 168.81,64.8 171.33,62.28 176.57,62.28 v2(176.97,62.68)
  BOTTOM w0.076: RC135.2 RC134.2
  BOTTOM w0.112: PRZ47.2 176.71,62.42 v2(176.97,62.68) ; RC134.2 141.31,78.18 141.7,77.78 v2(142.92,77.78)
VIDSCLK: length 55.6
  TOP w0.112: v2(177.73,62.68) 177.96,62.45 PRZ40.2
  IN1 w0.119: v2(142.91,77.08) 144.43,77.08 145.87,78.52 147.89,78.52 153.67,72.74 165.13,72.74 168.39,69.49 168.39,64.62 171.15,61.86 176.91,61.86 v2(177.73,62.68)
  BOTTOM w0.076: 140.88,77.91 140.81,77.97 139.16,77.97 137.34,79.79 137.34,80.27 136.88,80.73 UC1.AA1
  BOTTOM w0.112: 140.88,77.91 141.7,77.08 v1(142.32,77.08) v2(142.91,77.08) ; PRZ46.2 177.49,62.44 v2(177.73,62.68)
VIDSOUT: length 53
  TOP w0.112: v2(176.12,62.71) 176.44,62.39 PRZ42.2
  IN1 w0.119: v2(142.91,79.37) 148.24,79.37 154.02,73.59 165.48,73.59 169.23,69.84 169.23,64.98 171.5,62.71 v2(176.12,62.71)
  BOTTOM w0.076: 141.51,79.37 141.13,79.37 140.81,79.05 139.54,79.05 139.4,79.19 RC136.2 138.78,79.56 137.2,81.14 136.31,81.14 UC1.AA2
  BOTTOM w0.112: v2(142.91,79.37) 141.51,79.37 ; PRZ48.2 175.92,62.51 v2(176.12,62.71)
VL: length 3
  TOP w0.112: PC515.1 24.63,96.56 v1(24.95,96.87)
  TOP w0.508: PC515.1 24.63,95.6 24.6,95.56 v2(24.6,94.81)
  BOTTOM w0.254: PU501.15 24.66,95.11 24.62,95.08 24.62,94.86 24.6,94.84 v2(24.6,94.81)
VR_CAP: length 2.5
  TOP w0.112: CE23.1 43.85,66.42 44.15,66.72 UE1.18
VR_HOTL#: length 2.4
  BOTTOM w0.203: PUZ01.31 175.63,59.89 v1(175.43,60.08) 175.43,60.68 175.15,60.96 PRZ49.1
VRAM_ID1: length 22.4
  TOP w0.112: v2(120,53.45) 120.34,53.78 RC120.1 121.2,53.22 v1(121.2,52.54)
  IN1 w0.119: v2(106.69,51.3) 106.71,51.3 108.37,52.95 119.51,52.95 v2(120,53.45)
  BOTTOM w0.076: UC1.CE27 120.2,53.75 v2(120,53.45)
  BOTTOM w0.112: v2(106.69,51.3) 106.59,51.4 106.59,54.06 108.09,55.56 RC118.2
VRAM_ID2: length 7.6
  BOTTOM w0.076: 122.58,46.5 122.58,46.66 123.07,47.14 123.07,47.54 122.89,47.71 122.89,48.05 122.9,48.06 122.96,48.21 122.96,48.71 UC1.CN23
  BOTTOM w0.112: RC119.1 121.49,42.89 121.49,44.37 RC117.2 122.35,45.24 122.35,45.83 v1(122.43,45.9) 122.58,46.06 122.58,46.5
VRAM_RST#: length 34
  IN1 w0.119: v2(127.5,127.77) 127.86,127.41 127.86,125.28 132.34,120.8 144.4,120.8 147.88,117.33 149.28,117.33 v2(149.39,117.22)
  BOTTOM w0.102: 147.36,119.09 147.64,118.81 147.64,118.73 ; UV1.L10 127.93,128.2 v2(127.5,127.77)
  BOTTOM w0.112: v2(149.39,117.22) 149.29,117.12 RV37.1 RV38.1 CV97.1 147.64,118.73 ; v1(146.71,119.74) 147.36,119.09
VRAM_RST#_R: length 47.4
  TOP w0.112: v2(150.05,117.33) 150.05,117.33 v1(150.42,117.7)
  IN1 w0.119: v2(150.05,117.33) 150.81,116.57 160.07,116.57 164.06,120.56 164.06,132.66 161.36,135.35 155.87,135.35 v2(155.52,135.7)
  BOTTOM w0.102: 155.52,135.75 155.52,136.72 155.11,137.13 UV13.J2 ; UV15.J2 154.71,119.71
  BOTTOM w0.112: 155.52,135.75 v2(155.52,135.7) ; RV36.1 v2(150.05,117.33) 150.79,118.07 153.85,118.07 154.71,118.93 154.71,119.71
VRMP_CPU: length 4.6
  BOTTOM w0.203: PRZ35.2 PCZ23.1 172.63,51.23 172.98,51.58 v1(172.98,51.67) 172.98,51.97 173.23,52.22 PUZ01.12
VSA_SEN+: length 67.5
  TOP w0.254: v2(132.78,64.3) 132.78,64.11 133.04,63.86 134.82,63.86 135.04,64.07 136.05,64.07 136.9,64.92 138.53,64.92 140.27,66.66 143.24,66.66 143.68,66.23 144.06,66.23 RC164.2 144.48,66.16 146.91,66.16 151.42,61.66 v1(151.42,60.79) 151.42,58.8 152.18,58.03 153.09,58.03 153.69,57.44 154.73,57.44 v2(154.87,57.3)
  IN3 w0.254: v2(184.5,53.65) 183.47,54.68 183.47,57.17 181.26,59.38 181.26,60.07 180.45,60.88 172.69,60.88 171.79,61.78 170.47,61.78 169.26,60.57 169.26,59.94 167.86,58.54 161.06,58.54 159.89,57.38 154.95,57.38 v2(154.87,57.3)
  BOTTOM w0.102: UC1.BG7 132.78,64.53 v2(132.78,64.3)
  BOTTOM w0.254: PRZ03.1 v2(184.5,53.65)
VSA_SEN-: length 67.1
  TOP w0.254: v2(154.87,57.89) 154.81,57.82 153.92,57.82 153.33,58.42 152.43,58.42 151.8,59.05 151.8,61.78 147.04,66.54 144.48,66.54 RC165.1 144.19,66.61 143.8,66.61 143.39,67.02 140.09,67.02 138.34,65.27 136.75,65.27 135.92,64.45 135.16,64.45 134.83,64.78 133.23,64.78 132.79,65.23 v2(132.78,65.23)
  IN3 w0.254: v2(154.87,57.89) 155,57.76 159.77,57.76 160.94,58.92 167.71,58.92 168.88,60.1 168.88,60.73 170.31,62.16 171.95,62.16 172.85,61.26 180.7,61.26 181.71,60.26 181.71,59.44 183.87,57.28 183.87,55.05 v2(184.5,54.41)
  BOTTOM w0.102: UC1.BE7 132.78,65.45 v2(132.78,65.23)
  BOTTOM w0.254: PRZ07.1 v2(184.5,54.41)
VSN_1A_CPU: length 12.8
  TOP w0.112: v2(170.96,66.96) v1(170.28,66.96)
  TOP w0.254: v2(170.96,66.96) 171.45,66.48 PRZ52.1 PCZ28.1
  BOTTOM w0.203: v2(170.96,66.96) 170.96,66.38 171.55,65.79 171.55,64.13 170.47,63.05 170.47,60.96 170.68,60.75 171.51,60.75 172.63,59.62 172.88,59.62 173.23,59.28 PUZ01.25
VSN_1A_CPU_R: length 3.8
  TOP w0.112: v1(173.5,65.31) 173.22,65.59 PCZ28.2
  TOP w0.254: PRZ52.2 PCZ28.2 PRZ53.1 PCZ29.1
VSN_1B_CPU: length 3.2
  BOTTOM w0.203: PUZ01.44 179.2,55.3 179.57,54.92 179.76,54.92
  BOTTOM w0.254: PCZ07.2 180.49,54.61 PRZ08.2 179.89,54.92 179.76,54.92
VSN_2PH_CPU: length 5.3
  TOP w0.112: PRZ19.2 v1(180.42,49.79)
  TOP w0.254: PRZ19.2 PCZ11.2 179.87,51.75 v2(179.82,51.8)
  BOTTOM w0.203: PUZ01.48 178.73,53.7 178.91,53.51 178.91,52.45 179.38,51.98 179.64,51.98 v2(179.82,51.8)
VSN_2PH_CPU_R: length 3.6
  TOP w0.112: PRZ18.2 v1(183.17,51.74)
  TOP w0.254: PCZ11.1 181.35,51.74 PRZ18.2 ; PCZ11.1 PRZ19.1 ; PCZ11.1 PCZ10.2
VSNN_1B_CPU_R: length 5.2
  BOTTOM w0.112: v1(184.15,56.24) 183.96,56.06 183.96,55.28 183.54,54.86 183.27,54.86 182.96,54.55 PRZ07.2
  BOTTOM w0.254: PCZ07.1 181.26,55.24 PRZ08.1 181.27,54.46 PCZ06.2 182.13,54.41 PRZ07.2
VSP_1A_CPU: length 5.8
  TOP w0.254: v2(171.2,60.3) 171.26,60.24 v1(172.06,60.24) 172.13,60.24 172.45,60.55 PCZ35.2 172.37,61.35 PRZ58.2
  BOTTOM w0.203: v2(171.2,60.3) 171.87,59.63 171.87,58.32 172.09,58.1 PUZ01.24
VSP_1A_CPU_R: length 3.7
  TOP w0.112: v1(169.66,62.63) 170.06,63.04 PRZ59.2
  TOP w0.254: PCZ29.2 171.61,63.74 PRZ61.1 ; PRZ58.1 PRZ61.1 ; PRZ61.1 171.57,63.04 PRZ59.2
VSP_1B_CPU: length 6.5
  IN2 w0.254: v2(179.74,54.34) 179.48,54.34 179.13,53.99 179.13,53.38 179.46,53.04 v2(179.66,53.04)
  BOTTOM w0.112: v1(180.77,51.56) 180.29,52.03 PRZ04.2
  BOTTOM w0.203: PUZ01.45 179.13,54.9 179.48,54.55 179.54,54.55 179.74,54.35 v2(179.74,54.34)
  BOTTOM w0.254: v2(179.66,53.04) 179.99,52.72 PRZ04.2 PCZ04.2
VSP_2PH_CPU: length 5.6
  TOP w0.112: v1(178.77,53.44) 178.77,53.22 179.59,52.41 v2(179.64,52.41)
  TOP w0.254: v2(179.64,52.41) 179.76,52.41 179.99,52.64 PCZ10.1 PRZ14.2
  BOTTOM w0.203: PUZ01.47 178.85,54.1 179.23,53.72 179.23,52.81 v2(179.64,52.41)
VSPP_1B_CPU_R: length 3.8
  BOTTOM w0.112: v1(182.22,52.47) 181.97,52.72 PRZ04.1
  BOTTOM w0.254: PRZ04.1 PCZ04.1 182.02,53.61 PCZ06.1 182.86,53.55 PRZ03.2
VSUM+_VGA: length 15.9
  TOP w0.112: PRV07.2 v1(69.43,121.79)
  TOP w0.203: v2(73.3,126.26) 73.37,126.26 73.58,126.46 PUV01.14
  TOP w0.254: PRV24.2 68.08,119.88 68.95,120.75 69.35,120.75 69.88,121.28 69.88,121.52 PRV28.1 70.96,122.6 PCV28.1 PRV30.1 70.07,122.93 v2(70.01,122.87) 69.5,122.87 69.38,122.99 PCV30.1 68.36,122.14 PRV07.2
  IN1 w0.254: v2(70.01,122.87) 70.01,122.97 v2(73.3,126.26)
VSUM-_VGA: length 35.4
  TOP w0.254: 68.02,125.78 68.93,125.78 68.94,125.79 PCV23.2 ; 68.02,125.78 69.21,124.58 PCV32.1 ; 68.02,125.78 PCV22.2 ; PRV33.1 PRV35.1 ; PRV35.1 71.8,123.57 PRV25.2 71.98,122.69 72.76,122.69 73.01,122.44 v2(73.07,122.44) ; PRV35.1 71.07,124.4 PCV28.2 PRV30.2 69.43,124.4 PCV32.1 ; PCV32.1 69.21,123.91 PCV30.2 67.09,122.99 PRV08.2
  IN2 w0.254: v2(73.07,122.44) 74.82,122.44 76.92,120.34 83.47,120.34 84.62,119.19 88.99,119.19 89.31,119.52 90.31,119.52 v2(90.65,119.85)
  BOTTOM w0.254: PHV02.2 93.47,120.41 91.2,120.41 v2(90.65,119.85)
VTTREF_1.2V: length 3.8
  TOP w0.112: PCM19.1 36.78,32.3 37.33,32.85 37.33,33.09 37.63,33.38 v1(37.91,33.38)
  TOP w0.203: PUM01.4 36.45,30.95 36.41,30.98 36.41,31.82 PCM19.1
WAKEB: length 8
  BOTTOM w0.112: UV1.AJ27 113.83,141.49 113.67,141.49 113.36,141.19 113.36,140.94 112.93,140.5 112.28,140.5 111.22,139.44 v1(111.22,137.52) 110.92,137.22 RV163.1 RV162.2
WHITE_LED_BAT: length 4.8
  BOTTOM w0.112: C21.1 R27.2 Q4.1 18.68,130.13 v1(17.74,129.19)
WIFI_RF_EN: length 196.4
  TOP w0.112: v2(120.77,52.27) 121.15,51.89 121.15,50.63 120.9,50.37 120.9,46.49 120.39,45.99 120.39,44.88 RC175.2 ; v2(58.84,129.98) 60.42,129.98 v1(64.24,133.8) 65.38,134.93 DW2.1
  IN2 w0.124: v2(58.84,129.98) 58.85,129.97 58.85,127.51 55.98,124.65 53.01,124.65 43.21,114.85 43.21,113.21 41.94,111.94 41.94,104.82 48.31,98.45 48.31,94.06 46.83,92.58 46.83,87.86 45.83,86.85 45.83,81.41 45.49,81.07 45.49,78.49 46.77,77.21 46.77,71.49 46.97,71.29 46.97,67.8 50.82,63.96 50.82,57.94 52.4,56.36 52.4,48.21 54.52,46.09 54.52,43.21 56.45,41.27 58.59,41.27 61.29,38.57 63.57,38.57 63.96,38.18 70.84,38.18 71.35,38.69 76.22,38.69 76.51,38.4 78.23,38.4 80.66,40.83 81.74,40.83 82.41,41.5 90.67,41.5 91.11,41.94 93.55,41.94 94.17,42.56 107.34,42.56 112.61,47.83 113.21,47.83 114.26,48.88 117.63,48.88 117.95,49.21 119.41,49.21 120.05,49.84 120.05,51.56 120.76,52.27 v2(120.77,52.27)
  BOTTOM w0.089: v2(120.77,52.27) 121.25,52.45 UC1.CG25
WIFI_RF_EN_R: length 4.6
  TOP w0.112: DW2.2 v2(68.74,134.93) 69.13,134.93 v1(69.36,135.16)
  BOTTOM w0.112: JWLAN1.56 70.29,134.4 69.76,134.93 v2(68.74,134.93)
XCLK_BIASREF: length 3.5
  BOTTOM w0.254: RC83.1 138.97,50.6 138.14,51.44 UC1.CJ1
XDP_BPM#0: length 3.2
  BOTTOM w0.076: UC1.U1 136.74,83.37 137.2,83.37 137.28,83.28 139.06,83.28 TP2.1
XDP_BPM#1: length 2.5
  BOTTOM w0.076: TP3.1 137.92,83.53 136.33,83.53 135.98,83.17 UC1.U2
XDP_BPM#2: length 6.1
  BOTTOM w0.076: UC1.U3 135.43,83.17 135.73,82.86 136.65,82.86 136.9,83.12 137.15,83.12 137.19,83.08 139.66,83.08 140.31,83.73 TP4.1
XDP_BPM#3: length 1.2
  TOP w0.112: TP5.1 v2(134.4,83.75)
  BOTTOM w0.076: UC1.U4 134.6,83.56 v2(134.4,83.75)
XDP_HOOK0: length 1.1
  TOP w0.112: TPC10.1 RC155.2
XDP_HOOK3: length 2.2
  BOTTOM w0.112: TPC8.1 106.71,34.09 106.76,34.04 RC149.2 RC32.1
XDP_ITP_PMODE: length 7.7
  BOTTOM w0.076: 141.51,82.46 141.33,82.46 141.05,82.74 138.69,82.74 TPC7.1 138.31,82.35 137.45,82.35 137.32,82.23 134.97,82.23 UC1.W4
  BOTTOM w0.112: 141.51,82.46 RC153.2
XDP_PRDY#: length 3.3
  BOTTOM w0.076: UC1.W1 137.26,81.85 137.48,82.07 139.37,82.07 TP8.1
XDP_PREQ#: length 5.4
  BOTTOM w0.076: UC1.W2 136.15,81.6 137.26,81.6 137.51,81.85 140.42,81.85 TP7.1
XDP_PRSENT_CPU: length 3.2
  BOTTOM w0.112: RC154.2 143.24,87.9 TPC9.1
XTAL24_IN: length 7
  BOTTOM w0.076: 135.94,50.5 135.15,50.5 UC1.CK3
  BOTTOM w0.102: 135.94,50.5 135.99,50.55 136.3,50.55 137.39,49.47 137.39,49.31
  BOTTOM w0.112: 137.39,49.31 137.88,48.82 138.04,48.82 138.06,48.84 138.21,48.84 138.37,48.68 138.37,48.53 138.35,48.51 138.35,48.35 138.51,48.19 138.67,48.19 138.69,48.21 138.85,48.21 139.01,48.05 139.01,47.89 138.99,47.87 138.99,47.72 139.52,47.18 RC89.1
XTAL24_IN_R: length 3.2
  BOTTOM w0.112: RC89.2 141.88,47.18 RC90.1 142.64,47.16 CC9.1 142.95,47.15 143.02,47.07 143.41,47.07 YC1.3
XTAL24_OUT: length 5.9
  BOTTOM w0.102: 138.46,49.47 138.46,49.58 137.01,51.04 136,51.04 UC1.CK2
  BOTTOM w0.112: RC91.1 139.87,48.06 138.46,49.47
XTAL24_OUT_R: length 5.1
  BOTTOM w0.112: RC91.2 141.88,48.06 RC90.2 142.64,48.08 CC10.1 143.01,48.09 143.35,47.75 144.69,47.75 YC1.1
XTALIN: length 5.7
  BOTTOM w0.112: UV1.AM28 110.58,142.6 110.07,143.11 CV17.1 RV20.1 109.54,142.25 109.53,142.24 YV1.1
XTALOUT: length 9.4
  BOTTOM w0.112: YV1.3 106.66,140.15 107.84,141.33 RV20.2 CV18.1 110.47,140.47 v1(110.67,140.67) 112.16,142.16 113.3,142.16 UV1.AK28
N12281337: length 2.7
  TOP w0.112: RA10.2 34.9,16.44 34.58,16.12 34.58,14.92 34.47,14.81 UA1.10
N16741477: length 2
  TOP w0.102: TP67.1 119.57,125.82 v2(119,126.39)
  BOTTOM w0.102: v2(119,126.39) 119.33,126.39 UV1.AB8
N16741489: length 1.2
  TOP w0.102: v2(118.14,125.4) 117.7,124.96 TP63.1
  BOTTOM w0.102: UV1.AD7 v2(118.14,125.4)
N16741505: length 4.3
  BOTTOM w0.102: UV1.AB4 119.34,123.49 118.97,123.12 118.97,122.49 118.67,122.19
  BOTTOM w0.112: 118.67,122.19 117,120.52 TP69.1
N16741517: length 1.5
  TOP w0.102: TP61.1 116.85,128.33 v2(117.37,127.81)
  BOTTOM w0.102: v2(117.37,127.81) 117.37,127.77 UV1.AD9
N16741525: length 2.3
  TOP w0.102: v2(121.34,126.12) 122.2,125.26 TP71.1
  BOTTOM w0.102: UV1.Y8 120.86,126.6 v2(121.34,126.12)
N16741803: length 1.2
  TOP w0.508: RV29.2 118.37,138.69 v2(118.37,138.15)
  BOTTOM w0.254: UV1.AC22 118.36,137.78 118.36,138.14 v2(118.37,138.15)
N16741825: length 3.6
  TOP w0.102: RV59.2 119.24,139.11 119.63,139.5 v1(119.63,140.97)
  TOP w0.508: RV59.2 119.18,138.56 v2(119,138.39)
  BOTTOM w0.305: UV1.AB22 119,138.13 v2(119,138.39)
N16751828: length 1.1
  TOP w0.102: TP64.1 118.47,127.36 v2(118.12,127.01)
  BOTTOM w0.102: UV1.AC8 v2(118.12,127.01)
N16751830: length 1.1
  TOP w0.102: TP60.1 116.98,125.89 v2(117.29,126.2)
  BOTTOM w0.102: v2(117.29,126.2) 116.94,126.55 UV1.AE8
N16751834: length 1.1
  TOP w0.102: TP58.1 116.89,127.02 v2(116.54,127.02)
  BOTTOM w0.102: UV1.AE9 116.93,127.4 v2(116.54,127.02)
N16751836: length 1.6
  TOP w0.102: TP56.1 125.54,127.14 v2(126.01,127.14)
  BOTTOM w0.102: v2(126.01,127.14) 126.48,127.14 UV1.N9
N16751838: length 2.9
  BOTTOM w0.102: 119.12,122.19 119.34,122.41 UV1.AB2
  BOTTOM w0.112: 119.12,122.19 118.32,121.39 TP70.1
N16751842: length 1.5
  TOP w0.102: v2(119,127.18) 119.58,126.6 TP66.1
  BOTTOM w0.102: v2(119,127.18) 119.22,127.4 UV1.AB9
N16751844: length 1.3
  TOP w0.102: v2(118.99,127.9) 119.15,128.06 TP62.1
  BOTTOM w0.102: v2(118.99,127.9) 118.84,127.9 UV1.AC10
N16751848: length 1.3
  TOP w0.102: v2(127.35,127.19) 127.52,127.36 TP57.1
  BOTTOM w0.102: v2(127.35,127.19) 127.39,127.24 127.78,127.24 UV1.L9
N16751852: length 1.8
  TOP w0.102: v2(120.07,125.51) 120.9,126.34 TP68.1
  BOTTOM w0.102: v2(120.07,125.51) 119.83,125.51 UV1.AB7
N16751854: length 1.3
  TOP w0.102: TP65.1 118.5,125.77 v2(118.88,125.39)
  BOTTOM w0.102: UV1.AC7 118.54,125.73 v2(118.88,125.39)
N16751856: length 1.5
  TOP w0.102: v2(121.34,128.18) 121.75,127.77 TP59.1
  BOTTOM w0.102: UV1.Y11 v2(121.34,128.18)
N16751858: length 1.8
  TOP w0.102: v2(120.53,124.65) 120.89,125 TP72.1
  BOTTOM w0.102: UV1.Y7 120.74,125.54 120.53,125.33 v2(120.53,124.65)
N16808781: length 5.1
  BOTTOM w0.102: 112.45,128.54 113.51,128.54 113.96,129 UV1.AJ11
  BOTTOM w0.112: v1(110.74,126.44) RV157.1 111.34,127.49 112.39,128.54 112.45,128.54
N16808782: length 4.3
  BOTTOM w0.102: 112.45,130.23 113.3,130.23 UV1.AK12
  BOTTOM w0.112: 112.45,130.23 111.17,130.23 111.03,130.1 RV155.1 v1(110.74,131.11)
N16808783: length 2.7
  BOTTOM w0.102: UV1.AL11 112.45,129
  BOTTOM w0.112: 112.45,129 110.97,129 RV156.1
N16813004: length 6.9
  IN1 w0.508: v2(107.35,127.69) v2(109,126.04)
  BOTTOM w0.112: v2(109,126.04) v1(108.21,126.04)
  BOTTOM w0.508: v2(107.35,127.69) 107.67,128.01 RV87.2 108.04,127.99 RV84.2 ; v2(109,126.04) 108.81,125.85 RV26.1 RV25.2
N17003752: length 3
  TOP w0.112: RD1.2 v1(70.06,76.62) 69.6,76.62 v2(69.53,76.69)
  BOTTOM w0.089: v2(69.53,76.69) 69.58,76.74 JDIMM1.134
N17004366: length 2.7
  TOP w0.112: RD14.2 57.11,77.15 v2(56.9,76.94)
  BOTTOM w0.102: JDIMM2.134 57.1,76.74 v2(56.9,76.94)
N17283936: length 1.1
  TOP w0.112: RA5.1 v1(37.96,23.13)
N17389450: length 14.4
  TOP w0.127: v2(27.72,90.3) v1(27,90.3)
  IN3 w0.254: v2(27.72,90.3) 27.39,89.97 v2(27.39,86.66)
  BOTTOM w0.254: v2(27.72,90.3) 27.86,90.44 27.86,90.84 27.2,91.5 PR508.1 PC516.1 26.6,93.05 PR503.2 ; v2(27.39,86.66) 27.33,86.6 PD501.2 24.78,86.6 24.33,86.15 22.73,86.15 22.58,86 PR502.2 PR506.2
N17415515:
  vias: v1(75.5,142.22) v2(72.35,142.97) v2(72.35,142.36) v2(72.96,142.97) v2(72.96,142.36) v2(73.57,142.97) v2(73.57,142.36) v2(74.18,142.97) v2(74.18,142.36) v2(74.77,142.97) v2(74.77,142.38)
N17446666: length 2.9
  BOTTOM w0.112: v1(103.92,33.49) 103.72,33.28 R39.2 Q6.1
N17462309: length 3.3
  TOP w0.112: JDEG1.9 39.75,96.5 39.64,96.39 39.02,96.39 v1(38.52,95.88) 38.07,95.44 RE52.2
N17462311: length 3.2
  TOP w0.112: RE48.2 v1(45.06,95.91) 44.66,96.3 43.91,96.3 43.75,96.46 JDEG1.1
N17462343: length 2.6
  TOP w0.112: v1(46.29,96.96) RE65.2 45.73,97.91 v2(45.69,97.87)
  BOTTOM w0.112: JESPI1.8 v2(45.69,97.87)
N17746338: length 2.8
  TOP w0.112: RX19.1 v1(94.52,32.27)
  TOP w0.508: RX19.1 93.28,32.37 RX18.1 RX10.2
N17746442: length 7.6
  TOP w0.112: RX16.1 79.83,33.71 v1(80.16,33.38)
  TOP w0.254: RX15.1 81.92,36.15 81.56,35.79 81.56,35.38 ; 81.56,35.38 CX7.1 CX6.1 82.47,35.36 82.48,35.35 82.49,35.35 83.13,34.72 83.91,34.72 84.06,34.87 UX1.22 ; 81.56,35.38 80.7,35.38 CX5.1 80.67,35.36 79.83,34.51 RX16.1
N17747394: length 6.1
  BOTTOM w0.076: 138.62,91.28 136.88,89.53 135.67,89.53 135.32,89.18 UC1.G3 UC1.G4
  BOTTOM w0.112: RC171.1 139.04,91.69 138.62,91.28
N17747798: length 4.3
  TOP w0.112: v1(117.46,92.43) RC172.1 116.45,92.43 v2(115.73,93.15)
  BOTTOM w0.076: UC1.C34 115.54,91.53 115.54,92.2 115.35,92.39 115.35,92.77 v2(115.73,93.15)
N17847259: length 1.2
  TOP w0.102: TP78.1 112.92,127.07 v2(112.84,127.16)
  BOTTOM w0.102: v2(112.84,127.16) 113.07,127.4 UV1.AL9
N17877344: length 2.6
  BOTTOM w0.102: 124.94,122.19 124.94,122.29 UV1.R1
  BOTTOM w0.112: TP75.1 123.64,120.89 124.94,122.19
N17877347: length 2.2
  TOP w0.102: TP76.1 v2(123.86,124.39)
  BOTTOM w0.102: v2(123.86,124.39) 124.11,124.14 124.49,124.14 124.94,123.69 UV1.R3
N18346552: length 18
  BOTTOM w0.112: Q5.2 106.74,26.78 R41.2 C23.2 104.99,28.18 103.67,26.86 v1(100.76,26.86) 98.63,26.86 97.44,28.05 97.44,29.4 98.08,30.03 98.08,31.32 98.24,31.48 Q6.2
N18855880: length 7.3
  TOP w0.112: R15.2 v2(222.98,57.34) 223.16,57.51 v1(223.16,57.91) ; U1.3 v2(218.72,56.13)
  IN1 w0.119: v2(218.72,56.13) 221.78,56.13 v2(222.98,57.34)
N18983262: length 2.5
  TOP w0.112: v1(54.64,81.12) 54.85,80.92 RE39.1 54.85,79.95 53.95,79.05 CE20.2
N18984098: length 0.8
  TOP w0.112: RA8.1 CA20.2
N19343283: length 6.1
  BOTTOM w0.112: JSSD1.8 37.63,27.38 37.74,27.49 39.37,27.49 39.87,26.98 RS2.1
N19639840: length 3.1
  TOP w0.112: v1(169.35,33.29) 169.35,32.44 RS30.2 168.87,32.37 168.71,32.2 QS1.6 168.11,32.2 167.93,32.02 167.93,31.74 168.11,31.55 QS1.5
N19855003: length 2.8
  BOTTOM w0.112: UZ6.10 118.63,112.56 118.65,112.58 CZ36.2 117.86,113.8 v1(117.7,113.8)
N19855015: length 2.5
  BOTTOM w0.112: UZ6.12 119.43,112.47 119.54,112.58 CZ35.2 120.29,113.01 120.47,112.84 v1(120.49,112.84)
N19855442: length 4.1
  BOTTOM w0.112: UZ5.6 132.58,115.91 132.17,115.49 132.17,114.65 132.34,114.48 CZ28.1 132.88,113.6 v1(133.07,113.42)
N19964578: length 2
  TOP w0.112: RZ10.2 93.89,59.74 v1(94.29,60.14) 94.32,60.17 UZ7.4
N19964609: length 1.9
  TOP w0.127: UZ7.6 v1(97.9,63.42)
N20135010: length 3.6
  TOP w0.203: PCV33.2 72.91,125.34 73.41,125.84 73.87,125.84 74.08,126.04 74.08,126.37 73.98,126.47 PUV01.15
  TOP w0.254: PCV33.2 72.68,125.33 PRV33.2
N20135022: length 0.8
  TOP w0.254: PRV35.2 71.78,124.61 PCV33.1
N20135024: length 4.3
  TOP w0.178: PUV01.25 77.31,129.5 77.52,129.29 v1(78.34,129.29) 78.68,129.63 79.57,129.63 PRV13.2
  TOP w0.254: PRV13.2 79.66,129.73 PCV11.1
N20135039: length 6.6
  TOP w0.203: PUV01.11 72.38,126.82 72.23,126.68 71.81,126.68 71.05,127.44 v1(69.27,127.44) 67.29,127.44 67.03,127.17 PRV19.1
N20135040: length 4.5
  TOP w0.203: PCV25.1 74.46,125.55 74.46,126.61 74.38,126.69 PUV01.16
  TOP w0.254: PCV25.1 74.66,124.61 PRV29.1 74.72,124.39 PCV27.1 PRV34.2
N20135043: length 4.1
  TOP w0.203: PCV34.1 76.36,125.34 75.86,125.84 75.07,125.84 74.82,126.09 74.82,126.67 74.78,126.71 PUV01.17
  TOP w0.254: PCV34.1 77.55,125.34 PRV36.2
N20135126: length 31.3
  TOP w0.112: v2(88.5,120.07) v1(89.1,120.07)
  TOP w0.254: v2(67.15,125.03) 66.44,125.03 66.2,125.27 PRV18.1 PRV19.2
  IN1 w0.254: v2(88.5,120.07) 82.85,120.07 81.3,121.62 81.3,123.47 80.63,124.14 78.08,124.14 77.12,125.09 76.68,125.09 76.11,124.52 72.55,124.52 70.44,122.41 68.23,122.41 67.98,122.66 67.98,124.2 v2(67.15,125.03)
  BOTTOM w0.254: PHV01.1 v2(88.5,120.07)
N20135134: length 10.2
  TOP w0.112: PRV32.1 72.81,121.99 v1(72.75,122.04)
  TOP w0.203: v2(75.35,126.3) 75.18,126.47 PUV01.18
  TOP w0.254: PCV26.1 73.68,123.54 PRV26.2 PRV29.2 ; PCV26.1 73.35,122.8 73.13,123.03 v2(73.07,123.03) ; PCV26.1 73.68,122 PRV32.1 PRV31.1
  IN2 w0.254: v2(75.35,126.3) 75.35,125.3 v2(73.07,123.03)
N20135137: length 0.8
  TOP w0.254: PRV26.1 73.74,124.54 PCV25.2
N20135139: length 2.3
  TOP w0.112: PCV31.1 72.82,120.04 v1(72.55,119.77)
  TOP w0.254: PCV31.1 72.87,121.08 PRV32.2
N20135141: length 10.9
  TOP w0.203: PUV01.19 75.58,126.7 76.42,125.85 77.95,125.85 78.08,125.73 78.08,123.72 v1(77.65,123.29) 77.3,122.94 PRV27.1
  TOP w0.254: PCV26.2 74.93,122.8 75.41,122.32 PCV29.2 75.65,121.75 77.1,121.75 77.3,121.95 PRV27.1
N20135144: length 1.9
  TOP w0.112: PCV29.1 v1(76.46,121.08)
  TOP w0.254: PRV31.2 PCV29.1
N20135171: length 31.1
  TOP w0.254: PRV28.2 70.22,121.12 69.27,120.16 v2(69.01,120.16)
  IN2 w0.254: v2(69.01,120.16) 68.96,120.11 68.77,120.11 68.49,119.82 68.49,118.04 68.87,117.66 87.96,117.66 89.46,119.16 90.6,119.16 v2(91.29,119.85)
  BOTTOM w0.254: PHV02.1 94.16,119.89 93.44,119.89 93.3,120.03 91.47,120.03 v2(91.29,119.85)
N20135251: length 3
  TOP w0.112: PRV02.1 73.03,133.73 72.56,134.2 72.56,134.82 71.87,135.52 v1(71.29,135.52)
N20135257: length 3.3
  TOP w0.112: PRV10.1 v1(70.8,133.71)
  TOP w0.203: PRV10.1 71.63,133.55 PUV01.1
N20135258: length 3.7
  TOP w0.112: v1(69.44,133.37) 69.44,132.84 PRV09.1
  TOP w0.203: PUV01.2 71.18,131.1 70.77,131.5 70.77,131.91 70.35,132.33 PRV09.1
N20135263: length 1.8
  TOP w0.203: PRV04.1 73.96,133.47 74.78,132.66 PUV01.34
N20135264: length 2.4
  TOP w0.112: PRV05.1 74.82,133.73 75.24,134.15 75.24,135.37 v1(74.91,135.69)
N20756305: length 2.7
  TOP w0.112: QT1.6 21.39,115.31 RT23.2 ; QT1.6 QT1.5 ; QT1.6 v1(21.44,114.24)
N21269026: length 1.5
  TOP w0.112: v1(162.64,87.02) 162.19,87.47 161.35,87.47
N21273981: length 1.7
  TOP w0.112: PRG03.2 v1(154.79,93.34)
N21379353: length 2
  TOP w0.112: v1(23.16,95.65) 23.86,95.65 v2(23.96,95.75) 23.96,96.86 PC508.1
N22856216: length 1.4
  TOP w0.102: UL1.27 21.29,82.86 TP53.1
N22856217: length 3
  TOP w0.112: TP54.1 19.76,84.35 20.52,83.59 21.15,83.59 21.23,83.66 UL1.25
N22856235: length 3.6
  TOP w0.112: 20.66,79.77 RL7.2 20.66,78.85 v1(20.84,78.67)
  TOP w0.254: 20.66,79.77 21.36,80.47 21.36,81.02 21.6,81.26 UL1.31
N22856250: length 4.1
  TOP w0.112: UL2.3 19.69,88.96 21.04,88.96 RL10.2 21.41,88.72 v1(22.62,89.93)
N23133643: length 2.6
  TOP w0.112: v2(197.77,50.41) v1(197.2,50.41)
  TOP w0.508: PDB01.1 198.47,49.72 v2(197.77,50.41)
  BOTTOM w0.508: PRB15.1 v2(197.77,50.41)
N24460345: length 3.1
  BOTTOM w0.254: PR507.2 27.12,85.16 v1(26.95,85.34) 26.2,85.34 25.32,84.46 PD501.1
N24550044: length 2.9
  TOP w0.112: PCV24.1 92.45,127.99 92.99,127.45 94.78,127.45 v1(94.88,127.55)
N24550059: length 1
  TOP w0.112: PCV21.1 80.5,128.33 v1(80.63,128.46)
N24550063: length 34.6
  TOP w0.254: v2(95.47,125.03) 95.41,124.96 95.41,124.33 92.68,121.6 90.74,121.6 90.06,120.92 86.92,120.92 85.98,119.99 v1(78.96,119.99) 77.36,119.99 75.93,118.55 72.68,118.55 71.69,119.54 71.32,119.54 70.61,120.25 PRV22.1 69.97,120.25 68.18,118.46 PRV24.1
  BOTTOM w0.254: v2(95.47,125.03) 95.3,125.2 95.3,125.22 95.03,125.48 95.02,125.48 94.97,125.53 94.63,125.53 PLV01.3
N24550065: length 32.1
  TOP w0.254: v2(94.84,125.03) 94.97,124.9 94.97,124.46 92.49,121.98 90.61,121.98 89.92,121.28 86.78,121.28 85.86,120.37 v1(81.91,120.37) 77.24,120.37 75.85,118.97 72.76,118.97 71.84,119.9 71.47,119.9 71.03,120.33 71.03,121.59 71.4,121.95 PRV25.1
  BOTTOM w0.254: PLV01.2 95.78,124.39 95.35,124.39 94.84,124.9 v2(94.84,125.03)
N24550138: length 61.1
  TOP w0.112: v1(66.76,119.72) 67.22,120.18 PRV03.1
  TOP w0.254: v2(66.46,124.37) 66.35,124.26 66.35,122.33 66.9,121.79 PRV07.1 67.01,121.74 67.01,120.99 PRV03.1
  IN3 w0.254: v2(66.46,124.37) 66.46,124.23 66.81,123.88 68,123.88 68.63,124.51 68.63,125.38 65.73,128.27 65.73,130.16 66.67,131.1 67.14,131.1 68.97,132.93 72.91,132.93 75.93,135.95 77.82,135.95 79.4,137.53 79.4,141.51 81.87,143.98 92.75,143.98 94.84,141.88 94.84,135.68 v2(94.97,135.55)
  BOTTOM w0.254: PLV02.3 94.97,135.53 v2(94.97,135.55)
N24550140: length 3.1
  TOP w0.112: PCV09.1 92.42,131.9 92.95,132.43 94.67,132.43 v1(94.97,132.14)
N24550153: length 1.7
  TOP w0.112: PRV01.2 79.28,133.79 79.79,134.3 v1(79.79,134.55)
N24550158: length 56.1
  TOP w0.254: v2(67.05,124.37) 67.05,123.87 PRV08.1
  IN3 w0.254: v2(95.4,135.95) 95.28,136.07 95.28,141.94 92.89,144.33 81.67,144.33 79.05,141.71 79.05,137.68 77.71,136.34 75.81,136.34 72.76,133.28 68.83,133.28 67,131.45 66.52,131.45 65.38,130.3 65.38,128.12 68.27,125.23 68.27,124.66 67.88,124.26 67.15,124.26 v2(67.05,124.37)
  BOTTOM w0.254: v2(95.4,135.95) PLV02.2
N24557362: length 2.7
  TOP w0.102: TP77.1 122.59,123.83 v2(122.59,124.39)
  BOTTOM w0.102: UV1.U6 123.19,125 v2(122.59,124.39)
N24610461: length 3.2
  BOTTOM w0.254: PRH11.2 PCH11.1 164.17,43.65 v1(164.04,43.77) 163.64,44.17 PUH01.11
N24610467: length 1.6
  BOTTOM w0.254: PUH01.9 163.81,45.07 163.86,45.12 164.06,45.32 PCH10.1
N24610523: length 3.3
  BOTTOM w0.112: PCH14.2 165.25,45.39 165.6,45.74 v1(167.41,45.74)
  BOTTOM w0.254: PCH14.2 165.25,45.07 165.01,44.83 PRH12.1
N24610920: length 5
  BOTTOM w0.112: v1(167.22,47.11) 165.69,47.11 PRH05.2
  BOTTOM w0.254: PRH05.2 165.12,46.79 163.86,46.79 163.42,46.35 163.42,46.22 163.17,45.97 PUH01.7
N24874892: length 2.3
  BOTTOM w0.203: PRB19.2 205.65,49.33 204.83,48.52 PUB01.21
N24874930: length 4.9
  BOTTOM w0.112: v1(206.75,51.44) 206.87,51.33 206.87,50.77 206.9,50.73 206.9,49.93 206.49,49.51 PRB20.2
  BOTTOM w0.203: PUB01.22 205.23,48.43 205.83,49.03 206.21,49.03 206.41,49.23 PRB20.2
N25136715: length 4.4
  BOTTOM w0.112: RI14.2 25.12,89.92 24.05,89.92 23.48,89.36 DI1.3 v1(22.86,90.71)
N25136716: length 2.9
  BOTTOM w0.112: RI15.2 22.1,88.05 DI1.2 23.48,87.43 v1(23.48,86.76)
N25241223: length 6.5
  BOTTOM w0.112: UV15.J13 155.51,129.31 155.51,130.95 155.88,131.31 157.76,131.31 RV121.1 v1(159.41,132.01)
N25241225: length 3.7
  BOTTOM w0.112: UV15.J1 155.11,117.36 v1(154.64,116.89) 154.4,116.65 RV117.1
N25241231: length 12.8
  BOTTOM w0.102: UV15.J10 155.11,126.11 155.38,125.84 155.38,125.27 155.88,124.77 161.9,124.77 162.18,124.49
  BOTTOM w0.112: v1(165.88,124.18) 164.69,124.18 164.14,123.63 RV119.1 163.6,123.63 163.6,123.62 163.04,123.62 162.18,124.49
N25397464: length 1.9
  BOTTOM w0.112: v1(117.24,35.25) 117.32,35.17 RC45.1 CC5.2
N25403147: length 82.6
  TOP w0.112: v2(156.17,100.19) v1(156.74,100.19)
  IN1 w0.119: v2(142.15,90.48) 141.7,90.04 141.7,74.29 149.42,66.57 149.42,65.81 151.93,63.3 151.93,53.66 151.34,53.08 151.34,52.74 149.26,50.66 149.26,50.1 149.61,49.75 149.61,37.85 149.14,37.38 v2(149.13,37.38) ; v2(146.47,92.77) 147.35,93.66 147.35,98.74 148.8,100.19 v2(156.17,100.19)
  BOTTOM w0.112: v2(142.15,90.48) 144.43,92.77 v2(146.47,92.77) ; v2(149.13,37.38) 147.82,37.38 JDB1.4
  BOTTOM w0.254: RB7.1 v2(156.17,100.19)
N25403151: length 56.2
  TOP w0.112: v2(185.9,34.02) 185.9,32.67 185.26,32.02 184.26,32.02 RB9.1 ; v2(151.35,37.34) v1(151.35,36.79)
  IN1 w0.119: v2(151.35,37.34) 151.35,36.99 151.23,36.87 148.98,36.87 148.62,36.51 148.62,34.09 149.26,33.46 155.74,33.46 159.2,29.99 162.43,29.99 162.97,30.53 164.18,30.53 164.7,30.01 171.97,30.01 173.2,28.79 175.54,28.79 177.62,30.86 177.62,31.17 180.86,34.41 185.51,34.41 v2(185.9,34.02)
  BOTTOM w0.112: JDB1.8 147.81,36.6 149.61,36.6 149.79,36.78 150.85,36.78 150.94,36.87 151.35,37.28 v2(151.35,37.34)
N25403157: length 106.6
  TOP w0.112: RB10.1 55.53,25.64 v1(55.88,25.3) v2(56.48,24.7)
  IN1 w0.119: v2(56.48,24.7) 57.62,25.84 59.96,25.84 v2(60.48,26.37)
  IN2 w0.124: v2(63.53,29.01) 63.66,29.14 65.31,29.14 66.02,29.85 69.43,29.85 69.55,29.73 94.09,29.73 96.56,32.19 103.63,32.19 104.6,33.16 119.88,33.16 120.05,33.33 122.04,33.33 123.08,32.29 123.72,32.29 124.88,33.45 127.99,33.45 128.74,32.69 128.9,32.69 129.52,32.07 131.11,32.07 134.17,35.13 150.17,35.13 v2(150.91,35.87)
  BOTTOM w0.112: JDB1.14 147.81,35.4 150.69,35.4 150.91,35.62 v2(150.91,35.87) ; v2(60.48,26.37) 63.13,29.01 v2(63.53,29.01)
N25403161: length 41.2
  TOP w0.112: v1(168.25,57.26) RB11.1 169.58,57.01 v2(169.58,56.07)
  IN1 w0.119: v2(169.58,56.07) 166.98,53.46 166.98,46.01 167.63,45.36 167.63,44.42 167.21,44 165.94,44 164.12,42.18 164.12,41.03 163.44,40.35 155.13,40.35 153.58,38.8 153.58,36.79 151.9,35.11 150.13,35.11 v2(149.51,34.49)
  BOTTOM w0.112: v2(149.51,34.49) 149.4,34.6 JDB1.18
N25403175: length 101.1
  TOP w0.112: v2(209.81,56.28) 209.81,56.57 208.83,57.55 v1(208.83,57.69) 209.43,58.29 RB1.2
  IN1 w0.119: v2(209.81,56.28) 208.45,54.92 205.73,54.92 204.23,53.41 204.23,50.57 204.67,50.13 207.27,50.13 208.82,48.57 208.82,46.86 211.03,44.65 211.64,44.65 211.91,44.38 211.91,42.85 211.4,42.35 v2(210.34,42.35)
  IN2 w0.124: v2(143.44,36.92) 143.44,36.93 144.12,37.61 146.47,37.61 147.36,36.72 151.38,36.72 152.77,35.33 171.56,35.33 173.24,37 180.11,37 180.48,37.38 189.74,37.38 190.24,36.87 195.79,36.87 197.15,38.24 204.89,38.24 206.92,40.26 206.92,40.61 208.74,42.43 210.09,42.43 210.18,42.35 v2(210.34,42.35)
  BOTTOM w0.112: JDB1.3 145.63,37.4 143.93,37.4 v2(143.44,36.92)
N25403185: length 99.5
  TOP w0.112: RB2.2 v2(215.3,56.57) 215.3,56.05 v1(215.15,55.9)
  IN2 w0.124: v2(144.03,36.93) 144.48,37.38 146.37,37.38 147.26,36.49 151.29,36.49 152.68,35.1 171.66,35.1 173.33,36.78 180.2,36.78 180.58,37.15 189.65,37.15 190.15,36.65 195.88,36.65 197.24,38.01 204.99,38.01 207.09,40.12 208.2,40.12 209.46,41.37 210.32,41.37 212.28,43.33 212.28,44.98 212.75,45.46 215.86,45.46 215.91,45.4 v2(216.04,45.4)
  BOTTOM w0.112: v2(216.04,45.4) 216.42,45.02 216.44,45.02 216.77,44.69 218.38,44.69 218.9,45.21 218.9,47.98 218.36,48.51 218.36,55.37 216.73,57 215.72,57 v2(215.3,56.57) ; v2(144.03,36.93) 144.1,37 JDB1.5
N25403191: length 100.3
  TOP w0.112: v2(215.17,57.21) 214.54,56.57 RB3.2 ; v2(144.02,36.29) 144.06,36.33 v1(144.6,36.33)
  IN2 w0.124: v2(144.02,36.29) 144.89,37.16 146.28,37.16 147.17,36.27 151.19,36.27 152.58,34.88 171.75,34.88 173.17,36.29 195.85,36.29 197.34,37.78 205.08,37.78 207.19,39.89 208.3,39.89 209.55,41.15 210.41,41.15 212.51,43.24 212.51,44.89 212.84,45.23 215.64,45.23 v2(216.06,44.81)
  BOTTOM w0.112: v2(215.17,57.21) 216.82,57.21 218.58,55.46 218.58,48.6 219.11,48.06 219.11,45.12 218.46,44.48 216.68,44.48 216.34,44.81 v2(216.06,44.81) ; JDB1.7 144.33,36.6 v2(144.02,36.29)
N25403203: length 46
  IN1 w0.119: v2(177.4,46.29) 177.2,46.08 177.2,44.6 175.68,43.08 175.68,38.36 169.18,31.86 167.73,31.86 v2(167.55,31.68)
  BOTTOM w0.112: v2(167.55,31.68) 167.55,31.68 167.42,31.81 164.39,31.81 164.01,32.2 145.06,32.2 144.81,32.44 144.81,34.35 145.06,34.6 JDB1.17 ; v2(177.4,46.29) RB5.2
N25403205: length 45.4
  IN1 w0.119: v2(176.82,46.29) 176.96,46.15 176.96,44.67 175.46,43.17 175.46,38.45 169.09,32.08 167.78,32.08 v2(167.55,32.32)
  BOTTOM w0.112: JDB1.19 145.18,34.2 145.07,34.09 145.07,32.57 145.23,32.41 164.1,32.41 164.48,32.02 167.25,32.02 v2(167.55,32.32) ; RB6.2 v2(176.82,46.29) 176.91,46.38 v1(176.91,46.87)
N25403207: length 71.1
  TOP w0.254: RB4.2 165.18,68.84 v1(164.19,68.84) 163.79,68.84 163.61,69.02 v2(162.59,69.02)
  IN1 w0.119: v2(160.18,31.81) 160.18,37.02 162.34,39.17 163.99,39.17 165.26,40.44 165.26,41.59 165.9,42.22 166.61,42.22 168.46,44.08 168.46,45.7 167.97,46.2 167.97,48.1 169.36,49.5 169.36,50.25 171.85,52.74 171.85,58.75 171.36,59.24 170.21,59.24 169.36,60.1 169.36,62.51 162.85,69.02 v2(162.59,69.02)
  BOTTOM w0.112: JDB1.13 145.34,35.4 144.56,34.62 144.56,32.32 144.94,31.94 160.05,31.94 v2(160.18,31.81)
N25403817: length 57.7
  TOP w0.112: v2(186.51,34.02) 186.51,32.79 185.53,31.81 184.35,31.81 RB8.1
  IN1 w0.119: v2(151.93,37.27) 151.83,37.27 151.57,37.01 151.57,36.9 151.32,36.65 149.08,36.65 148.85,36.42 148.85,34.19 149.35,33.68 155.83,33.68 159.3,30.21 162.34,30.21 162.87,30.75 164.27,30.75 164.79,30.23 172.06,30.23 173.29,29.01 175.45,29.01 177.39,30.95 177.39,31.26 180.76,34.63 185.9,34.63 v2(186.51,34.02)
  BOTTOM w0.112: JDB1.6 147.81,37 150.77,37 150.96,37.19 150.96,37.5 151.19,37.72 151.51,37.72 151.93,37.31 v2(151.93,37.27)
N25728593: length 4.1
  TOP w0.112: R63.2 61.57,38.67 Q18.1 v1(59.44,38.35)
N25766780: length 4.5
  BOTTOM w0.112: TP34.1 113.45,44.89 113.57,45.02 113.57,46.29 114.13,46.84 114.13,47.48 114.32,47.67 114.57,47.67 114.9,47.99 UC1.CR35
N25941897: length 4.9
  TOP w0.112: UZ4.3 70.45,31.8 CZ20.1 RZ4.2 71.52,30.68 72.69,30.68 v1(72.94,30.42)
N25941919: length 3.2
  TOP w0.112: UZ4.6 70.45,35.23 70.77,35.56 71.67,35.56 CZ22.1 v1(73.1,35.31)
N26325502: length 1.2
  TOP w0.381: CC50.1 121.74,60.42 v2(121.51,60.19)
  BOTTOM w0.254: v2(121.51,60.19) 121.55,60.19 121.88,60.52 UC1.BP24
N26532121: length 6.8
  BOTTOM w0.112: TP51.1 68.62,117.67 68.62,121.48 69.04,121.9 JWLAN1.6
N26532122: length 9.9
  BOTTOM w0.112: TP52.1 67.35,118.17 67.35,122.62 69.13,124.4 JWLAN1.16
N26604037: length 2.6
  TOP w0.112: v1(61.27,125.84) UV3.4 60.27,124.79 RV166.1
N28160180: length 1
  BOTTOM w0.112: R31.2 v1(30.59,126.17)
N28160287: length 17.1
  TOP w0.112: v2(15.02,126.93) v1(15.02,127.44)
  IN3 w0.135: v2(2.96,131.08) 3.59,130.45 3.59,128.84 4.86,127.57 13.2,127.57 13.83,126.93 v2(15.02,126.93)
  BOTTOM w0.112: R28.1 v2(15.02,126.93)
  BOTTOM w0.254: LED1.4 2.55,131.49 v2(2.96,131.08)
N28160289: length 21.9
  IN3 w0.135: v2(2.96,130.48) 3.35,130.09 3.35,128.74 4.76,127.33 13.1,127.33 14,126.42 15.53,126.42 15.91,126.8 v2(15.91,129.98)
  BOTTOM w0.112: R27.1 15.96,130.03 v2(15.91,129.98) v1(15.91,129.45)
  BOTTOM w0.254: LED1.2 3.42,131.68 3.42,130.87 3.04,130.48 v2(2.96,130.48)
N28162955: length 3.4
  TOP w0.254: DA4.2 20.57,12.75 v1(20.86,13.04) 21.6,13.77 RA29.1
N28162971: length 3.2
  TOP w0.254: DA4.3 18.86,11.68 v1(20.85,11.68) 21.48,11.68 RA32.1
N28248044: length 14.4
  TOP w0.112: UC6.2 97.95,38.86 98.46,39.36 98.62,39.36 v1(99.7,40.45) 99.91,40.65 99.91,43.86 99.23,44.54 98.79,44.54 98.44,44.89 98.44,46.57 96.73,48.27 RC144.2 CC68.1 95.87,49.55 DZ4.2
N28248145: length 4.5
  BOTTOM w0.112: v1(122.4,107.2) 122.96,107.75 123.99,107.75 124.44,107.3 CZ6.1 124.68,107.01 UZ1.12
N28248150: length 4.7
  BOTTOM w0.112: UZ1.10 124.46,106.21 CZ7.1 123.92,105.71 123.15,105.71 122.88,105.98 v1(121.88,105.98)
N28372404: length 3
  TOP w0.254: UX1.1 89.93,33.87 90.1,33.7 90.1,33.35
  TOP w0.508: RX10.1 91.37,33.19 90.89,32.71 v1(90.62,32.71) 90.1,33.23 90.1,33.35
N28372567: length 2.2
  TOP w0.112: UX1.2 90.37,34.37 v1(90.69,34.06) 91.59,34.06 RX11.2
N28373080: length 2.2
  TOP w0.112: TP80.1 90.1,36.37 UX1.6
N28373361: length 3.7
  TOP w0.112: UX1.7 89.9,36.87 91.06,35.71 92.07,35.71 TP81.1
N28373436: length 3.2
  TOP w0.112: v1(91.14,39.02) 91.42,38.74 RX12.1
  TOP w0.254: 90.24,37.8 89.81,37.37 UX1.8
  TOP w0.508: 90.24,37.8 90.43,37.99 RX12.1
N28373601: length 2.5
  TOP w0.254: RX13.1 v1(84.54,39.17) 84.72,39.17 85.28,38.61 UX1.16
N28373753: length 2.9
  TOP w0.254: RX14.1 82.55,33.65 82.92,33.28 v1(83.43,33.28) 83.43,33.81 83.99,34.37 UX1.23
N28405142: length 5
  TOP w0.112: RX17.1 RX20.1 86.39,41.07 86.72,40.74 v1(86.72,39.89) 86.72,39.7 86.28,39.26 UX1.14
N28406092: length 11.3
  TOP w0.112: v2(32.04,31.75) 31.5,32.28 31.5,33.08 v1(31.93,33.51) 32.25,33.83 RS34.1
  BOTTOM w0.112: JSSD1.10 37.13,27.43 36.94,27.62 36.17,27.62 v2(32.04,31.75)
N28483977: length 3.9
  TOP w0.112: v1(208.71,47.9) 208.71,48.46 208.5,48.66 PR45.1
  TOP w0.254: PQ13.2 209.51,49.07 PR45.1 PR35.2 207.74,48.65 PR31.2
N28483985: length 7
  TOP w0.112: v1(207.64,53.17) 208.7,52.12 PR32.2
  TOP w0.254: PR32.2 209.08,51.62 210.69,50.01 210.69,49.17 209.95,48.43 PQ13.3
N28484391: length 1.1
  TOP w0.112: PR33.2 v1(172.16,34.02)
N28484395: length 2.1
  TOP w0.112: PR40.1 170.76,36.34 170.76,37.13 v1(171.15,37.53)
N28484412: length 4.9
  TOP w0.112: PQ12.2 v1(168.18,37.16)
  TOP w0.254: PR36.2 166.3,34.93 PR44.2 167.75,34.93 168.18,35.36 PQ12.2
N28484439: length 3.4
  TOP w0.112: PQ11.2 163.75,36.59 v1(163.2,36.04)
  TOP w0.254: PC14.2 PR43.1 164.12,37.27 164.25,37.14 PQ11.2
N28484451: length 5.5
  TOP w0.112: v1(212.96,51.71) 212.96,50.29 PR34.2
  TOP w0.254: PR34.2 212.41,49.73 PQ13.6 211.25,49.73 211.04,49.53 211.04,49.17 211.13,49.08 PQ13.5 212.39,49.08 PR38.1
N28606987: length 2.1
  TOP w0.112: RX21.2 89.3,38.9 88.88,38.9 88.78,38.79 UX1.9
N28607577: length 2.4
  TOP w0.112: v1(88.85,30.69) RX22.2 88.78,31.75 UX1.32
N28610747: length 4
  BOTTOM w0.112: v1(24.77,119.34) 25.23,118.88 RT4.1 25.39,118.3 25.83,117.86 26.89,117.86 27.09,117.66 UT1.9
N28610884: length 4.4
  BOTTOM w0.112: UT1.16 31,119.29 31.15,119.44 32.98,119.44 33.1,119.31 RT7.1 v1(33.87,120.42)
N28610886: length 2.2
  BOTTOM w0.112: UT1.20 32.84,116.66 v1(32.93,116.57) 33.23,116.26 RT6.1
N28610888: length 3.3
  BOTTOM w0.112: UT1.1 31,115.52 31.28,115.25 v1(32.81,115.25) 33.45,115.25 RT5.1
N28610904: length 2.2
  BOTTOM w0.112: UT1.17 32.47,118.16 v1(32.86,118.55) RT8.1
N28610914: length 3.9
  BOTTOM w0.112: UT1.8 26.27,117.16 RT3.2 26.1,117.28 25.61,117.78 v1(24.06,117.78)
N28610924: length 2.6
  BOTTOM w0.112: v1(26.15,119.31) RT4.2 26.28,118.16 UT1.10
N28610938: length 3.9
  BOTTOM w0.112: v1(24.1,115.83) 24.6,115.83 24.74,115.97 25.59,115.97 26.13,116.52 RT2.2 26.28,116.66 UT1.7
N28766144: length 3.6
  BOTTOM w0.112: PRB29.2 208.39,47.46 v1(207.77,47.46)
  BOTTOM w0.203: PRB29.2 208.16,46.53 207.9,46.53 207.49,46.12 PUB01.27
N28767446: length 21
  IN1 w0.254: v2(207.49,46.79) 207.17,47.11 205.21,47.11 202.23,50.1 201.01,50.1 199.68,48.76 v2(199.68,40.95)
  BOTTOM w0.112: v2(199.68,40.95) v1(199.68,40.42)
  BOTTOM w0.203: v2(207.49,46.79) 207.22,46.52 PUB01.26
  BOTTOM w0.254: v2(199.68,40.95) 200.26,41.54 PRB28.2 200.27,41.85 PRB27.2
N28810503: length 4.5
  TOP w0.203: CZ16.1 43.9,58.54 v1(43.09,58.54) 42.69,58.15 40.94,58.15 40.68,58.42 40.5,58.42 40.48,58.43 UZ3.12
N28810563: length 2.5
  TOP w0.203: CZ17.1 42.07,57.4 v1(40.95,57.4) 40.43,57.4 40.2,57.63 UZ3.10
N28866422: length 11.7
  BOTTOM w0.254: PRB02.3 190.92,52.19 191.17,52.45 193.85,52.45 v1(195.88,50.41) 196.57,49.73 196.57,48.13 197.52,47.18 198.71,47.18 PRB12.1
N28866424: length 2.6
  TOP w0.254: v2(208.12,45.68) 208.47,45.33 PRB31.1
  BOTTOM w0.203: v2(208.12,45.68) 208.12,45.42 207.92,45.21 v1(207.81,45.21) 207.29,45.21 207.18,45.32 PUB01.29
N28866425: length 2.9
  TOP w0.112: v1(210.13,47.28) 210.47,46.93 PRB32.1
  TOP w0.254: PRB32.1 209.67,46.24 PCB13.1 PRB31.2
N28866427: length 4.2
  TOP w0.112: PRB34.1 v1(207.37,46.26)
  TOP w0.254: PRB33.1 208.39,44.51 v2(208.14,44.76) 207.88,45.02 207.57,45.02 PRB34.1
  BOTTOM w0.203: PUB01.30 207.11,44.92 207.21,44.83 208.07,44.83 v2(208.14,44.76)
N28866460: length 43.6
  IN1 w0.254: v2(178.85,41.71) 178.7,41.71 178.44,41.46 178.44,40.51 181.19,37.77 188.77,37.77 189.8,38.79 191.02,38.79 192.06,37.75 196.99,37.75 199.72,40.48 200.63,40.48 202.22,42.07 206.76,42.07 208.06,43.37 210.09,43.37 v2(210.35,43.62)
  BOTTOM w0.112: v2(210.35,43.62) 210.37,43.65 210.37,43.84 v1(210.73,44.19)
  BOTTOM w0.254: v2(178.85,41.71) 178.57,41.71 176.95,43.33 176.95,44.51 176.69,44.76 PRB01.3 ; PRB37.2 v2(210.35,43.62)
N28866517: length 43.4
  IN1 w0.254: v2(210.35,42.98) 208.18,42.98 206.91,41.71 202.36,41.71 200.78,40.13 199.86,40.13 197.08,37.35 191.96,37.35 190.87,38.44 190.09,38.44 189.06,37.41 181.01,37.41 178.09,40.33 178.09,41.66 v2(178.7,42.28)
  BOTTOM w0.254: PRB01.2 177.58,44.76 177.33,44.51 177.33,43.49 v1(178.01,42.81) 178.54,42.28 v2(178.7,42.28) ; v2(210.35,42.98) 210.09,42.73 PRB36.2
N28866577: length 0.9
  BOTTOM w0.203: PCB11.1 210.52,45.33 PRB30.2
N28866586: length 2.6
  BOTTOM w0.127: PCB06.1 v1(197.81,43.56)
  BOTTOM w0.635: PRB14.2 PCB06.1
N28866613: length 11.8
  BOTTOM w0.254: PRB02.2 190.92,53.02 191.11,52.83 194,52.83 196.95,49.88 196.95,48.29 v1(197.31,47.92) 197.68,47.56 198.71,47.56 PRB11.1
N29056076: length 3.3
  TOP w0.112: PQB29.1 v1(178.05,32.61)
  TOP w0.254: PQB29.1 177.62,34.78 PQB28.2
N29179188: length 9
  TOP w0.112: PRB03.1 v1(192.78,63.37)
  TOP w0.254: PQB30.3 193.63,62.29 v2(194.02,62.68) 194.05,62.71 194.05,63.07 PRB03.1
  IN2 w0.254: v2(194.02,62.68) 194.02,59.3 192.88,58.16 v2(191.49,58.16)
N29179461:
  vias: v2(192.25,54.73) v2(192.25,54.1) v2(192.25,53.46) v2(192.57,55.24) v2(192.88,54.73) v2(192.88,54.1) v2(192.88,53.46) v2(193.52,54.73) v2(193.52,54.1) v2(193.52,53.46) v3(193.14,52.27)
N29179498: length 3.3
  TOP w0.112: PRB06.1 191.7,60.47 191.7,61.49 v1(191.64,61.55)
  TOP w0.508: PQB11.4 PRB06.1
N29179534: length 13.7
  TOP w0.112: v1(194.74,59.52) 194.74,59.39 PRB07.1
  TOP w0.508: PQB12.4 v2(186.85,55.24) ; PQB30.1 193.47,60.39 PRB06.2 v2(193.09,59.3) PCB01.2 193.95,58.61 PRB07.1
  IN1 w0.508: v2(186.85,55.24) 190.92,59.3 v2(193.09,59.3)
N32437553: length 4.9
  BOTTOM w0.102: 155.7,147.42 155.7,146.98 155.43,146.71 155.43,146.25 UV13.J13
  BOTTOM w0.112: v1(157.35,149.69) 156.67,149 RV123.1 155.7,148.31 155.7,147.42
N33188643: length 3.3
  TOP w0.203: RA23.2 35.64,18.73 v1(35.64,18.14) 35.64,17.33 RA24.1 34.72,17.2 CA32.1
N35136189: length 3.3
  TOP w0.112: v1(196.4,64.41) 195.41,63.42 PRB04.1
  TOP w0.508: PQB30.2 194.67,62.29 PRB03.2 PRB04.1
N35174703: length 3.7
  TOP w0.112: PRB42.2 204.89,53.48 203.95,54.41 v1(203.95,54.58)
  TOP w0.254: PRB42.2 205.6,52.74 PRB43.1 205.6,52.06 PQB33.1
N35174707: length 3.1
  TOP w0.112: v1(202.99,53.58) 203.49,53.08 203.49,52.97 PCB36.1
  TOP w0.254: PCB36.1 PRB43.2 204.68,51.72 PQB32.2
N36085760: length 2.6
  TOP w0.112: PD3.1 v1(49.39,134.59)
  TOP w0.254: PR7.2 51.52,134.86 51.25,134.59 PD3.1
N36085833: length 8.1
  TOP w0.112: PR7.1 v1(51.91,136.86)
  TOP w0.254: PR7.1 52.66,135.77 53.06,135.37 PQ2.1 53.06,134.21 PR4.2 52.76,133.89 53.68,132.98 PQ1.2
N37640332: length 4.2
  TOP w0.102: RV2.2 124.27,127.61 v1(124.27,126.63)
  TOP w0.381: v2(125.93,127.82) 125.36,128.39 RV2.2
  BOTTOM w0.254: v2(125.93,127.82) 126.31,128.2 UV1.N10
N37640410: length 2.4
  TOP w0.102: v2(120.12,138.49) 120.66,137.96 v1(120.84,137.96)
  TOP w0.508: RV3.1 120.12,139.07 v2(120.12,138.49)
  BOTTOM w0.381: UV1.AA22 120.12,138.02 v2(120.12,138.49)
N37828209: length 2.5
  TOP w0.102: v1(122.21,137.93) 121.94,137.93 v2(121.36,138.51)
  TOP w0.508: RV1.1 121.25,138.62 v2(121.36,138.51)
  BOTTOM w0.381: UV1.Y22 121.36,137.82 v2(121.36,138.51)
N38038746: length 2.8
  BOTTOM w0.112: v1(150.99,114.64) 150.94,114.68 CV96.1 150.57,115.73 150.5,115.66 RV36.2 RV37.2
N38038992: length 7
  TOP w0.102: v2(129.35,126.15) 129.35,126.36 129.71,126.72 v1(129.97,126.72) 129.97,126.5 129.83,126.37 129.83,126.01 130.29,125.55 130.29,124.64 129.76,124.11 CV98.2
  BOTTOM w0.102: v2(129.35,126.15) 128.94,126.56 UV1.K8
N38038994: length 4.6
  TOP w0.102: v2(128.47,125.58) 128.65,125.58 128.96,125.26 128.96,123.79 129.25,123.51 v1(129.25,123.17) 129.25,123.05 129.13,122.93 CV99.2
  BOTTOM w0.102: UV1.L7 128.16,125.58 v2(128.47,125.58)
N38038995: length 2.5
  TOP w0.102: RV40.2 130.32,119.53 130.32,119.21 v1(130.74,118.79)
  TOP w0.112: CV98.1 RV40.2
