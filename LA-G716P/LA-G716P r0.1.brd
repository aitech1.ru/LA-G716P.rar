# Allegro board LA-G716P r0.1.brd (continued)
## Routing (per net, layer and track width the routed paths; a pad name or vN(x,y) marks a point on that pad's centre or on a via; arc(x,y) is an arc through that point) (continued)
M_CASA#0: length 43.3
  TOP w0.127: v2(132.75,136.09) 133.02,136.09 133.13,136.2 133.13,136.86 133.28,137 133.53,137 133.66,136.88 133.66,136.17 133.78,136.04 134.04,136.04 134.16,136.17 134.16,136.69 134.29,136.82 135.21,136.82 135.83,137.45
  TOP w0.14: 135.83,137.45 136.4,138.01 138.34,138.01 139.33,139 141.32,139 141.38,139.05 141.95,139.05 142.09,139.19 142.09,139.9 142.23,140.04 142.51,140.04 142.65,139.9 142.65,139.19 142.79,139.05 143.08,139.05 143.2,139.18 143.2,139.93 143.32,140.04 v1(143.85,140.04) 144.23,140.04 144.71,140.52 148,140.52 148.1,140.62 148.1,141.38 148.26,141.54 159.18,141.54 159.28,141.44 159.28,140.93 159.14,140.79 155.36,140.79 155.26,140.69 155.26,140.03 154.81,139.58 154.59,139.58 154.29,139.28 154.29,138.7 v2(153.93,138.35)
  BOTTOM w0.102: v2(132.75,136.09) 132.57,136.09 132.18,135.7 132.01,135.7 131.71,135.4 131.53,135.4 131.34,135.21 UV1.G19
  BOTTOM w0.112: UV13.L3 v2(153.93,138.35)
M_CASA#1: length 43.1
  TOP w0.127: v2(131.66,132.37) 131.78,132.49 132.83,132.49 133.55,131.77 135.39,131.77 135.58,131.58 136.58,131.58
  TOP w0.14: 136.58,131.58 136.58,131.58 138.83,131.58 139.08,131.84 139.57,131.84 139.71,131.7 139.71,131.28 139.85,131.14 140.13,131.14 140.27,131.28 140.27,131.7 140.41,131.84 140.69,131.84 140.83,131.7 140.83,131.28 140.97,131.14 141.25,131.14 141.39,131.28 141.39,131.7 141.53,131.84 141.81,131.84 141.95,131.7 141.95,131.28 142.09,131.14 142.37,131.14 142.5,131.28 142.5,131.7 142.64,131.84 142.92,131.84 143.06,131.7 143.06,131.28 143.2,131.14 143.48,131.14 143.62,131.28 143.62,131.7 143.76,131.84 144.04,131.84 144.18,131.7 144.18,131.28 144.32,131.14 144.6,131.14 144.74,131.28 144.74,131.7 144.88,131.84 145.16,131.84 145.3,131.7 145.3,131.28 145.44,131.14 145.72,131.14 145.86,131.28 145.86,131.7 146,131.84 146.39,131.84 146.53,131.7 146.53,131.28 146.67,131.14 146.95,131.14 147.09,131.28 147.09,131.7 147.23,131.84 148.49,131.84 148.65,131.67 v1(148.65,131.21) 148.65,129.96 148.84,129.77 150.53,129.77 150.62,129.67 150.62,129.26 150.52,129.16 148.83,129.16 148.71,129.04 148.71,127.54 150.5,125.75 v2(151.11,125.75)
  BOTTOM w0.102: 131.34,132.68 v2(131.66,132.37)
  BOTTOM w0.112: UV15.L3 153.91,121.31 153.91,122.58 153.63,122.86 153.02,122.86 151.11,124.76 v2(151.11,125.75)
  BOTTOM w0.127: UV1.G16 131.34,132.68
M_CKEA0: length 44.4
  TOP w0.127: v2(129.12,137.04) 129.4,136.75 129.4,135.51 129.96,134.96 129.96,134.63 130.34,134.25 131.57,134.25 132,134.68 134.13,134.68 134.69,134.12 135.11,134.12 135.62,134.62 136.58,134.62
  TOP w0.14: 136.58,134.62 139.92,134.62 140.13,134.41 145.42,134.41 145.56,134.55 145.56,136.65 145.69,136.78 146.06,136.78 146.17,136.67 146.17,134.55 146.31,134.41 146.74,134.41 146.88,134.55 v1(146.88,135.61) 146.88,136.63 147.03,136.78 147.31,136.78 147.45,136.64 147.45,134.55 147.59,134.41 147.96,134.41 148.1,134.55 148.1,135.3 148.23,135.43 148.6,135.43 148.74,135.29 148.74,134.55 148.88,134.41 149.16,134.41 149.29,134.55 149.29,135.22 149.43,135.36 151.02,135.36 151.24,135.58 151.24,136.19 151.37,136.32 152.29,136.32 152.4,136.22 152.4,135.58 152.62,135.36 153.67,135.36 153.91,135.59 153.91,136.19 154.01,136.29 154.54,136.29 154.74,136.49 v2(154.74,137.49)
  BOTTOM w0.127: v2(129.12,137.04) 128.94,136.86 UV1.K20 ; UV13.J3 155.11,137.9 154.74,137.53 v2(154.74,137.49)
M_CKEA1: length 43.8
  TOP w0.127: 135.35,133.02 134.95,133.43 134.34,133.43 133.97,133.79 132.25,133.79 131.99,133.53 131.99,133.36 131.74,133.11 130.95,133.11 130.92,133.14 130.74,133.14 v2(130.42,133.46)
  TOP w0.14: 135.35,133.02 139.27,133.02 139.49,132.8 v1(146.78,132.8) 153.53,132.8 154.34,133.61 157.57,133.61 158.38,132.8 158.38,124.74 155.82,122.18 155.82,121.53 v2(155.57,121.28)
  BOTTOM w0.112: v2(155.57,121.28) 155.2,120.91 UV15.J3
  BOTTOM w0.127: UV1.J17 129.88,134 v2(130.42,133.46)
M_CLKA0: length 43.5
  TOP w0.122: v2(154.71,144.73) 155,145.02 155,145.97 155.12,146.09 155.12,147.63 154.97,147.78 154.97,148.72 RV78.2
  IN3 w0.132: v2(154.71,144.73) 154.86,144.73 155.01,144.57 155.01,144.26 155.22,144.05 155.22,143.02 154.91,142.71 153.38,142.71 153.38,142.72 148.32,142.72 147.97,142.37 147.97,141.48 147.8,141.3 147.12,141.3 146.99,141.43 146.99,142.65 146.73,142.91 146.15,142.91 145.89,142.65 145.89,141.43 145.76,141.3 145.36,141.3 145.23,141.43 145.23,142.67 144.97,142.93 144.39,142.93 144.13,142.67 144.13,141.43 143.99,141.3 143.6,141.3 143.46,141.43 143.46,141.78 143.2,142.04 142.62,142.04 142.36,141.78 142.36,141.43 142.23,141.3 141.83,141.3 141.7,141.43 141.7,142.09 141.44,142.35 140.86,142.35 140.6,142.09 140.6,141.43 140.47,141.3 139.33,141.3 139.2,141.43 139.2,142.09 138.94,142.35 138.23,142.35 137.97,142.09 137.97,141.43 137.84,141.3 135.76,141.3 135.51,141.04 133.03,141.04 132.97,141.11 132.18,141.11 132.12,141.04 131.53,141.04 131.47,141.11 131.2,141.11 v2(130.94,141.37)
  BOTTOM w0.102: v2(130.94,141.37) 130.57,141 UV1.H26 ; v2(154.71,144.73) 155.11,145.12 UV13.J12
M_CLKA1: length 42.6
  TOP w0.122: RV85.2 155.6,131.72 155.6,130.58 154.8,129.78 154.8,128.55 154.97,128.39 154.97,127.98 v2(154.68,127.69)
  IN3 w0.132: v2(131.74,126.97) 131.69,127.02 131.52,127.02 131.42,126.92 131.42,126.63 131.91,126.13 133.03,126.13 133.81,126.91 135.85,126.91 136.05,126.71 141.08,126.71 141.27,126.9 141.27,126.99 141.53,127.25 142.11,127.25 142.38,126.99 142.38,126.57 142.51,126.44 142.9,126.44 143.04,126.57 143.04,127.53 143.3,127.8 143.88,127.8 144.14,127.53 144.14,126.57 144.27,126.44 144.67,126.44 144.8,126.57 144.8,127.56 145.06,127.82 145.64,127.82 145.9,127.56 145.9,126.57 146.03,126.44 146.51,126.44 146.64,126.57 146.64,127.67 146.9,127.93 147.48,127.93 147.74,127.67 147.74,126.57 147.87,126.44 150.37,126.44 150.67,126.14 150.67,125.38 150.8,125.25 154.88,125.25 155.07,125.44 155.07,127.54 154.92,127.69 v2(154.68,127.69)
  BOTTOM w0.102: v2(131.74,126.97) 131.34,127.37 UV1.G9
  BOTTOM w0.112: UV15.J12 155.1,128.11 v2(154.68,127.69)
M_CLKA#0: length 43.9
  TOP w0.122: v2(155.51,144.73) 155.22,145.02 155.22,145.87 155.34,146 155.34,147.72 155.19,147.87 155.19,148.72 RV79.2
  IN3 w0.132: v2(155.51,144.73) 155.41,144.73 155.23,144.55 155.23,144.35 155.44,144.14 155.44,142.93 155,142.49 153.29,142.49 153.28,142.5 148.41,142.5 148.19,142.28 148.19,141.38 147.89,141.08 147.03,141.08 146.77,141.34 146.77,142.56 146.64,142.69 146.24,142.69 146.11,142.56 146.11,141.34 145.85,141.08 145.27,141.08 145.01,141.34 145.01,142.58 144.87,142.71 144.48,142.71 144.35,142.58 144.35,141.34 144.08,141.08 143.51,141.08 143.24,141.34 143.24,141.69 143.11,141.82 142.72,141.82 142.58,141.69 142.58,141.34 142.32,141.08 141.74,141.08 141.48,141.34 141.48,142 141.35,142.13 140.95,142.13 140.82,142 140.82,141.34 140.56,141.08 139.24,141.08 138.98,141.34 138.98,142 138.84,142.13 138.32,142.13 138.19,142 138.19,141.34 137.93,141.08 135.86,141.08 135.6,140.82 132.94,140.82 132.87,140.88 132.27,140.88 132.21,140.82 131.44,140.82 131.37,140.88 131.11,140.88 v2(130.94,140.71)
  BOTTOM w0.102: UV13.J11 155.11,144.33 v2(155.51,144.73) ; v2(130.94,140.71) 130.94,140.6 UV1.H25
M_CLKA#1: length 42.8
  TOP w0.122: RV86.2 155.82,131.72 155.82,130.48 155.03,129.69 155.03,128.65 155.19,128.48 155.19,127.98 155.48,127.69 v2(155.48,127.67)
  IN3 w0.132: v2(155.48,127.67) 155.29,127.49 155.29,125.35 154.97,125.03 150.71,125.03 150.45,125.29 150.45,126.05 150.28,126.22 147.78,126.22 147.52,126.48 147.52,127.58 147.39,127.71 146.99,127.71 146.86,127.58 146.86,126.48 146.6,126.22 145.94,126.22 145.68,126.48 145.68,127.47 145.55,127.6 145.15,127.6 145.02,127.47 145.02,126.48 144.76,126.22 144.18,126.22 143.92,126.48 143.92,127.44 143.79,127.57 143.39,127.57 143.26,127.44 143.26,126.48 143,126.22 142.42,126.22 142.15,126.48 142.15,126.9 142.02,127.03 141.63,127.03 141.49,126.9 141.49,126.81 141.17,126.49 135.96,126.49 135.75,126.69 133.9,126.69 133.13,125.91 131.82,125.91 131.19,126.54 131.19,126.72 v2(130.94,126.97)
  BOTTOM w0.102: UV1.H9 130.94,127 v2(130.94,126.97)
  BOTTOM w0.112: UV15.J11 155.11,127.38 155.4,127.67 v2(155.48,127.67)
M_CSA#0: length 43.3
  TOP w0.127: v2(130.16,138.99) 129.87,138.99 129.76,139.1 129.76,140.14 129.94,140.32 131.15,140.32 132.25,141.42 132.75,141.42 132.91,141.59 132.91,142.3
  TOP w0.14: 132.91,142.3 132.91,142.49 132.83,142.58 132.25,142.58 132.06,142.77 132.06,143.96 132.32,144.22 135.34,144.22 135.45,144.11 135.45,143.63 135.63,143.44 137.63,143.44 139.35,145.17 v1(144.6,145.17) 144.74,145.17 146.27,146.7 152.88,146.7 153.11,146.93 153.11,147.39 153.35,147.63 154.08,147.63 154.31,147.41 154.31,145.95 154.3,145.94 154.3,144.55 154.53,144.32 156.46,144.32 156.88,143.9 157.51,143.9 157.65,144.04 157.65,144.28 157.21,144.73 v2(157.1,144.73)
  BOTTOM w0.112: v2(157.1,144.73) 156.71,145.12 UV13.G12
  BOTTOM w0.127: v2(130.16,138.99) 130.15,138.99 130.15,138.56 129.95,138.36 129.95,137.94 130.29,137.6 UV1.H22
M_CSA#1: length 41.9
  TOP w0.127: v2(130.93,128.51) 130.64,128.21 130.64,127.64 130.89,127.39 131.08,127.39 131.34,127.13 131.34,126.82 132.1,126.06 133.35,126.06 135.38,124.04 136.5,124.04
  TOP w0.14: 136.5,124.04 138.94,121.6 v1(141.44,121.6) 144.34,121.6 144.87,121.06 145.26,121.06 147.85,118.47 153.31,118.47 155.05,120.21 155.05,120.67 155.16,120.79 155.16,121.94 157.53,124.31 157.53,127.28 v2(157.13,127.68)
  BOTTOM w0.102: v2(130.93,128.51) 131.15,128.51 131.7,129.05 131.7,130.04 UV1.G13
  BOTTOM w0.127: v2(157.13,127.68) UV15.G12
M_DA0: length 59.5
  IN3 w0.142: v2(161.91,136.73) 163.49,138.3 163.49,142.46 163.92,142.88 163.92,148.3 161.76,150.46 161.76,150.82 159.27,153.31 137.4,153.31 134.87,150.77 132.33,150.77 127.87,146.31 127.87,144.59 128.02,144.44 128.02,144.43 129.26,143.19 v2(129.26,142.99)
  BOTTOM w0.127: UV13.A2 v2(161.91,136.73) ; v2(129.26,142.99) 129.26,142.99 129.33,142.93 129.33,142.18 UV1.K27
M_DA1: length 55.7
  IN3 w0.142: v2(129.26,143.82) 128.34,144.74 128.34,145.81 132.61,150.09 135.15,150.09 137.68,152.62 158.99,152.62 160.84,150.77 160.84,150.09 162.89,148.04 162.89,142.82 162.47,142.41 162.47,138.09 v2(161.11,136.73)
  BOTTOM w0.127: UV13.B2 v2(161.11,136.73) ; v2(129.26,143.82) 129.26,143.82 129.26,143.69 129.74,143.21 UV1.J29
M_DA2: length 49.9
  IN3 w0.142: v2(129.71,144.93) 129.4,145.24 129.4,145.84 130.19,146.63 130.19,146.63 132.92,149.36 132.93,149.36 133.16,149.6 135.24,149.6 135.25,149.61 135.35,149.61 137.68,151.94 158.7,151.94 159.82,150.82 159.82,150.33 162.33,147.82 162.33,143.23 161.91,142.81 v2(161.91,139.13)
  BOTTOM w0.127: 129.96,144.78 130.22,144.53 130.22,143.75 130.54,143.43 UV1.H30 ; v2(161.91,139.13) UV13.A4
  BOTTOM w0.14: v2(129.71,144.93) 129.86,144.78 129.96,144.78
M_DA3: length 46.4
  IN3 w0.142: v2(161.12,139.13) 161.52,139.53 161.52,147.95 159.46,150.01 158.39,150.01 157.94,150.46 157.94,150.65 157.46,151.13 137.83,151.13 135.58,148.88 133.12,148.88 130.67,146.43 130.67,146.14 130.6,146.06 130.6,145.98 v2(130.09,145.47)
  BOTTOM w0.127: UV1.H32 130.54,145.03 130.4,145.17 ; UV13.B4 161.11,139.13 v2(161.12,139.13)
  BOTTOM w0.14: 130.4,145.17 v2(130.09,145.47)
M_DA4: length 44.4
  IN3 w0.142: v2(131.66,143.41) 133.81,143.41 135.45,145.05 144.21,145.05 144.39,144.88 144.39,144.5 144.56,144.33 144.97,144.33 145.14,144.51 145.14,145.82 145.32,146 145.67,146 145.84,145.82 145.84,144.51 146.02,144.33 146.37,144.33 146.54,144.51 146.54,145.82 146.72,146 147.07,146 147.24,145.82 147.24,144.51 147.42,144.33 147.83,144.33 148.01,144.51 148.01,146.08 148.21,146.28 149.84,146.28 149.96,146.4 153.24,146.4 153.7,145.94 157.26,145.94 157.5,145.7 157.5,137.94 v2(157.1,137.54)
  BOTTOM w0.127: UV13.F2 v2(157.1,137.54) ; v2(131.66,143.41) 131.66,143.32 UV1.G29
M_DA5: length 45.8
  IN3 w0.142: v2(132.5,142.99) 132.8,142.7 135.22,142.7 135.31,142.61 135.49,142.61 135.67,142.79 135.67,144.17 135.87,144.37 136.3,144.37 136.48,144.2 136.48,142.64 136.65,142.47 137.03,142.47 137.23,142.67 137.23,142.96 137.4,143.13 137.73,143.13 137.91,143.31 137.91,143.97 138.08,144.14 138.39,144.14 138.57,143.97 138.57,143.17 138.74,143 139.1,143 139.28,143.17 139.28,144.31 139.45,144.48 139.78,144.48 139.92,144.34 139.92,143.79 140.07,143.65 140.44,143.65 140.58,143.79 140.58,144.3 140.72,144.45 141.05,144.45 141.22,144.27 141.22,143.82 141.4,143.65 141.75,143.65 141.92,143.82 141.92,144.32 142.1,144.5 142.45,144.5 142.62,144.32 142.62,143.82 142.8,143.65 143.15,143.65 143.32,143.82 143.32,144.2 143.5,144.37 143.85,144.37 144.03,144.2 144.03,143.82 144.2,143.65 148.31,143.65 148.53,143.87 148.53,145.17 149.13,145.76 150.07,145.76 150.25,145.94 152.54,145.94 153.35,145.13 154.23,145.13 154.29,145.19 155.81,145.19 155.88,145.12 156.52,145.12 156.69,144.95 156.69,140.89 156.31,140.51 156.31,138.94 156.92,138.33 v2(157.1,138.33)
  BOTTOM w0.127: v2(132.5,142.99) 132.14,142.63 UV1.F28 ; v2(157.1,138.33) 157.5,138.73 UV13.F4
M_DA6: length 44.6
  IN3 w0.142: v2(158.7,138.33) 158.7,138.33 159.11,138.73 159.11,139.53 159.04,139.59 159.04,143.26 159.11,143.33 159.11,146.52 158.09,147.54 157.35,147.54 157.22,147.68 153.97,147.68 153.96,147.67 150.6,147.67 150.59,147.66 150.24,147.66 150.07,147.83 150.07,148.14 149.89,148.32 149.54,148.32 149.37,148.14 149.37,147.83 149.19,147.66 148.84,147.66 148.66,147.83 148.66,148.14 148.49,148.32 147.99,148.32 147.81,148.14 147.81,147.56 147.64,147.39 147.29,147.39 147.11,147.56 147.11,148.14 146.94,148.32 146.53,148.32 146.36,148.14 146.36,147.54 146.18,147.36 145.86,147.36 145.67,147.55 145.67,148.14 145.49,148.32 145.14,148.32 144.97,148.14 144.97,147.55 144.79,147.38 144.44,147.38 144.27,147.55 144.27,148.14 144.09,148.32 143.74,148.32 143.57,148.14 143.57,147.55 143.38,147.36 137.71,147.36 136.69,146.35 134.89,146.35 134.55,146.01 134.26,146.01 133.14,144.89 v2(132.19,144.89)
  BOTTOM w0.127: UV1.F32 132.14,144.85 132.18,144.9 132.18,144.89 v2(132.19,144.89) ; v2(158.7,138.33) 158.7,138.33 158.7,138.33 UV13.E4
M_DA7: length 45.9
  IN3 w0.142: v2(158.7,136.74) 158.3,137.13 158.3,139.4 157.93,139.77 157.93,143.29 158.3,143.66 158.3,146.51 158.09,146.73 156.85,146.73 156.82,146.76 149.39,146.76 149.31,146.68 143.82,146.68 143.64,146.5 143.64,145.91 143.47,145.74 143.12,145.74 142.94,145.91 142.94,146.5 142.77,146.68 142.35,146.68 142.17,146.5 142.17,145.91 142,145.74 141.65,145.74 141.47,145.91 141.47,146.5 141.3,146.68 140.95,146.68 140.77,146.5 140.77,145.91 140.6,145.74 140.25,145.74 140.07,145.91 140.07,146.5 139.9,146.68 139.54,146.68 139.37,146.5 139.37,145.91 139.19,145.74 138.84,145.74 138.67,145.91 138.67,146.5 138.49,146.68 138.14,146.68 137.97,146.5 137.97,145.91 137.79,145.74 135.17,145.74 134.84,145.41 134.33,145.41 133.19,144.26 v2(131.61,144.26)
  BOTTOM w0.127: UV13.E2 v2(158.7,136.74) ; UV1.F30 132.14,143.67 131.61,144.2 v2(131.61,144.26)
M_DA8: length 26.9
  IN1 w0.147: v2(137.45,143.91) 138.35,143.91 140.42,145.98 152.59,145.98 153.45,145.12 154.06,145.12 154.3,144.89 154.3,144.46 154.44,144.32 157.49,144.32 v2(157.9,144.73)
  BOTTOM w0.102: UV1.C30 133.85,143.4 134.23,143.78 135.31,143.78
  BOTTOM w0.112: v2(157.9,144.73) 157.51,144.33 UV13.F11
  BOTTOM w0.14: 135.31,143.78 137.33,143.78 v2(137.45,143.91)
M_DA9: length 37.4
  IN1 w0.145: v2(131.76,142.13) 131.76,142.9 132.06,143.21 132.06,144.11 134.02,146.06 ; v2(161.12,146.33) 161.12,146.33 161.52,146.73 161.52,147.29
  IN1 w0.147: 134.02,146.06 136.29,148.34 136.29,148.34 137.55,149.6 159.95,149.6 161.52,148.02 161.52,147.29
  BOTTOM w0.112: v2(161.12,146.33) 160.72,145.93 UV13.B13
  BOTTOM w0.127: UV1.F27 131.81,142.13 v2(131.76,142.13)
M_DA10: length 27.4
  IN1 w0.147: v2(158.7,144.73) 157.5,143.52 152.67,143.52 151.06,145.13 140.14,145.13 137.82,142.81 136.81,142.81 136.05,142.05 v2(136.04,142.05)
  BOTTOM w0.112: v2(158.7,144.73) 158.31,144.33 UV13.E11
  BOTTOM w0.127: UV1.A28 134.86,142.28 135.31,142.28
  BOTTOM w0.14: 135.31,142.28 135.56,142.28 135.79,142.05 v2(136.04,142.05)
M_DA11: length 30.7
  IN1 w0.145: 152.85,142.57 159.76,142.57 161.11,143.93 v2(161.12,143.93)
  IN1 w0.147: v2(137.21,142.06) 137.64,142.06 139.91,144.33 150.47,144.33 151.27,143.53 151.89,143.53 152.85,142.57
  BOTTOM w0.112: UV13.B11 160.72,144.33 v2(161.12,143.93)
  BOTTOM w0.127: 135.31,142.99 134.15,142.99 133.76,142.6 UV1.C28
  BOTTOM w0.14: 135.31,142.99 136.28,142.99 v2(137.21,142.06)
M_DA12: length 33.2
  IN1 w0.145: 134.98,146.06 133.39,144.47 v2(133.39,142.17) ; 158.91,147.04 158.91,146.53 v2(158.7,146.33)
  IN1 w0.147: 158.91,147.04 158.91,148.01 157.73,149.19 138.11,149.19 135.61,146.69 134.98,146.06
  BOTTOM w0.102: v2(133.39,142.17) 133.31,142.17 UV1.E27
  BOTTOM w0.112: UV13.E13 158.31,145.93 v2(158.7,146.33)
M_DA13: length 40.8
  IN1 w0.145: v2(161.92,146.33) 161.92,146.33 162.04,146.46 162.04,147.42 ; v2(131.74,141.47) 130.88,142.33 130.88,144.75 132.2,146.06
  IN1 w0.147: 162.04,147.42 162.04,148.07 160.11,150 136.13,150 132.2,146.06
  BOTTOM w0.102: v2(131.74,141.47) 131.74,141.4 UV1.G26
  BOTTOM w0.112: UV13.A13 161.52,145.93 v2(161.92,146.33)
M_DA14: length 32.6
  IN1 w0.145: 135.31,145.41 135.12,145.22 135.12,144.74 134.88,144.5 134.66,144.5 134.45,144.3 134.45,144.05 134.03,143.63 134.03,142.93 133.96,142.87 133.96,142.46 133.86,142.36 133.86,142 133.62,141.77 133.61,141.77 v2(133.33,141.48)
  IN1 w0.147: 135.31,145.41 138.69,148.79 157.43,148.79 158.4,147.82 158.4,146.82 v2(157.9,146.32)
  BOTTOM w0.112: UV13.F13 157.51,145.93 v2(157.9,146.32)
  BOTTOM w0.127: v2(133.33,141.48) 133.33,141.48 133.33,141.47 133.38,141.42 133.38,141.03 UV1.D26
M_DA15: length 33.9
  IN1 w0.145: v2(161.92,143.93) 161.91,143.92 161.91,143 161.02,142.11 151.67,142.11 ; 135.31,141.38 135.02,141.38 134.11,140.48 v2(132.54,140.48)
  IN1 w0.147: 151.67,142.11 150.27,143.51 149.78,143.51 149.43,143.85 140.2,143.85 139.98,143.63 139.95,143.63 137.7,141.38 135.31,141.38
  BOTTOM w0.102: UV1.F25 132.22,140.2 132.5,140.48 v2(132.54,140.48)
  BOTTOM w0.112: v2(161.92,143.93) 161.52,144.33 UV13.A11
M_DA16: length 21.7
  IN3 w0.142: v2(153.11,139.13) 152.69,139.54 152.69,140.98 152.27,141.4 149.14,141.4 148.18,140.43 136.74,140.43 136.7,140.39 136.44,140.39 v2(135.93,139.88)
  BOTTOM w0.102: UV13.M4 152.71,138.73 v2(153.11,139.13) ; UV1.A25 135.04,140.2 135.31,139.93
  BOTTOM w0.14: v2(135.93,139.88) 135.36,139.88 135.31,139.93
M_DA17: length 17.7
  IN3 w0.142: v2(136.7,139.95) 137.32,139.32 146.97,139.32 147.18,139.53 149.51,139.53 v2(149.91,139.13)
  BOTTOM w0.102: UV1.C25 134.11,140.2 134.55,140.64 134.85,140.64 ; UV13.T4 149.51,138.73 v2(149.91,139.13)
  BOTTOM w0.127: 134.85,140.64 134.87,140.66 135.31,140.66
  BOTTOM w0.14: v2(136.7,139.95) 136.4,140.25 136.35,140.25 135.93,140.66 135.31,140.66
M_DA18: length 22.1
  IN3 w0.142: v2(137.47,139.96) 137.52,140.01 148.6,140.01 148.97,140.38 151.54,140.38 151.85,140.06 151.85,139.58 v2(152.31,139.13)
  BOTTOM w0.102: v2(152.31,139.13) 151.91,138.73 UV13.N4 ; UV1.E25 133.19,140.2 133.53,140.54 134.11,140.54 134.77,141.2
  BOTTOM w0.127: 135.31,141.39 134.97,141.39 134.77,141.2
  BOTTOM w0.14: v2(137.47,139.96) 137.47,140.12 136.2,141.39 135.31,141.39
M_DA19: length 17.2
  IN3 w0.142: v2(135.26,139.37) 135.71,139.37 136.09,138.99 136.69,138.99 136.95,138.73 146.94,138.73 147.34,139.13 v2(149.11,139.13)
  BOTTOM w0.102: UV13.U4 148.71,138.73 v2(149.11,139.13) ; v2(135.26,139.37) 135.26,139.55 135.03,139.78 134.09,139.78 133.71,139.4 UV1.D24
M_DA20: length 18.9
  IN3 w0.142: v2(149.11,136.73) 148.88,136.73 147.77,135.62 136.06,135.62 134.93,136.75 134.12,136.75 133.75,137.12 133.75,137.87 v2(133.33,138.29)
  BOTTOM w0.102: v2(133.33,138.29) 133.24,138.29 UV1.E23 ; v2(149.11,136.73) 149.51,137.12 UV13.T2
M_DA21: length 22.9
  IN3 w0.142: v2(132.57,138.17) 132.71,138.17 133.25,137.63 133.25,137.09 134.46,135.88 135.03,135.88 135.95,134.96 150.43,134.96 151.24,135.77 151.24,136.45 v2(151.51,136.73)
  BOTTOM w0.102: UV13.N2 151.91,137.12 v2(151.51,136.73) ; UV1.F23 v2(132.57,138.17)
M_DA22: length 17.2
  IN3 w0.142: v2(134.1,138.28) 134.54,137.85 135.32,137.85 135.61,137.55 135.61,136.97 136.46,136.13 147.46,136.13 148.05,136.72 v2(148.3,136.72)
  BOTTOM w0.102: UV13.U2 v2(148.3,136.72)
  BOTTOM w0.127: v2(134.1,138.28) 133.62,137.8 UV1.D22
M_DA23: length 24.9
  IN3 w0.142: v2(131.66,137.16) 132.8,137.16 134.39,135.57 134.87,135.57 136.1,134.34 151.64,134.34 151.82,134.51 152.35,135.04 v2(152.35,136.73)
  BOTTOM w0.102: v2(152.35,136.73) 152.71,137.08 UV13.M2
  BOTTOM w0.127: v2(131.66,137.16) 131.98,137.16 UV1.F21
M_DA24: length 31.8
  BOTTOM w0.102: UV1.E21 133.24,136.69 135.06,136.69 135.4,137.04
  BOTTOM w0.127: 153.09,147.42 153.09,144.99 152.71,144.61 UV13.M11 ; 136.58,138.9 136.58,138.76 135.44,137.62 135.44,137.07 135.4,137.04
  BOTTOM w0.14: 153.09,147.42 153.09,147.54 152.76,147.87 152.76,147.89 150.62,150.03 146.44,150.03 v1(143.89,147.48) 141.65,145.24 141.65,143.16 137.6,139.11 136.78,139.11 136.58,138.9
M_DA25: length 28.9
  BOTTOM w0.102: UV1.D20 133.71,136.2 134.01,135.89 134.27,135.89 134.28,135.91 134.78,135.91 135.66,136.79 ; 152.28,147.42 152.28,146.36 UV13.M13
  BOTTOM w0.127: 135.66,136.79 135.66,137.43 136.58,138.35
  BOTTOM w0.14: 152.28,147.42 152.28,147.69 150.57,149.4 146.7,149.4 v1(145.62,148.32) 142.15,144.85 142.15,142.77 137.73,138.35 136.58,138.35
M_DA26: length 28.6
  BOTTOM w0.102: 136.58,137.7 135.88,137 135.88,136.7 134.88,135.7 134.41,135.7 134.4,135.69 133.88,135.69 133.87,135.7 132.81,135.7 132.51,135.4 UV1.F19 ; UV13.N13 151.91,145.94 151.49,146.35 151.51,147.42
  BOTTOM w0.14: 136.58,137.7 136.69,137.8 v1(137.47,137.8) 138.12,137.8 142.66,142.35 142.66,144.46 146.96,148.76 150.17,148.76 151.51,147.42
M_DA27: length 26.8
  BOTTOM w0.102: 150.63,147.42 150.63,146.74 150.97,146.4 151.09,146.4 151.47,146.02 151.47,144.77 UV13.N11 ; UV1.A19 134.56,135.42 134.88,135.42 135.94,136.47 136.58,137.11
  BOTTOM w0.14: 150.63,147.42 149.73,148.32 147.42,148.32 143.12,144.02 143.12,141.76 v1(139.53,138.16) 138.54,137.17 136.64,137.17 136.58,137.11
M_DA28: length 21.8
  BOTTOM w0.102: 136.05,134.76 135.74,134.76 135.2,134.22 134.88,134.22 134.76,134.34 134.31,134.34 134.27,134.29 134.01,134.29 133.8,134.51 133.71,134.6 UV1.D18
  BOTTOM w0.127: UV13.U13 148.56,145.77 148.34,145.77 148.08,145.52
  BOTTOM w0.14: 148.08,145.52 147.89,145.52 145.48,143.11 145.48,140.75 v1(144.35,139.61) 139.5,134.76 136.05,134.76
M_DA29: length 24
  BOTTOM w0.102: UV1.F17 132.51,134.17 133.85,134.17 133.93,134.09 134.35,134.09 134.39,134.13 134.68,134.13 134.8,134.01 135.28,134.01 135.55,134.28 136.41,134.28
  BOTTOM w0.127: 148,144.86 148.37,145.24 148.37,145.27 148.57,145.46 148.6,145.46 148.67,145.53 149.11,145.53 UV13.T13
  BOTTOM w0.14: 148,144.86 146.12,142.98 146.12,140.48 v1(141.68,136.04) 139.92,134.28 136.41,134.28
M_DA30: length 20
  BOTTOM w0.102: UV1.A17 136.16,133.8
  BOTTOM w0.127: UV13.U11 148.37,144.33 148,143.95 148,143.94
  BOTTOM w0.14: 136.16,133.8 140.33,133.8 v1(143.83,137.29) 146.88,140.34 146.88,142.82 148,143.94
M_DA31: length 22.3
  BOTTOM w0.102: UV1.C17 134.1,133.8 134.41,133.49 134.41,133.49 136.04,133.49
  BOTTOM w0.127: 147.36,139.93 147.36,142.76 148.5,143.89 149.08,143.89 UV13.T11 ; 136.04,133.49 136.28,133.49 136.58,133.19
  BOTTOM w0.14: 136.58,133.19 140.63,133.19 v1(146.37,138.94) 147.36,139.93
M_DA32: length 37.3
  IN3 w0.142: v2(132.97,133.31) 132.41,132.75 132.41,132.53 134.44,130.5 134.66,130.5 136.52,128.64 140.21,128.64 140.99,129.42 154.62,129.42 154.76,129.28 154.76,129.05 154.91,128.9 157.35,128.9 157.54,128.71 157.54,121.52 157.74,121.32 v2(157.95,121.32)
  BOTTOM w0.102: UV1.E17 132.97,133.77 v2(132.97,133.31)
  BOTTOM w0.112: UV15.F4 157.55,121.71 v2(157.95,121.32)
M_DA33: length 38.6
  IN3 w0.142: v2(158.62,121.31) 158.29,121.64 158.29,122.53 158.7,122.93 158.7,129.17 158.13,129.73 148.12,129.73 147.75,130.1 141.11,130.1 140.11,129.1 136.46,129.1 134.69,130.87 134.44,130.87 132.91,132.39 132.91,132.65 133.58,133.31 v2(133.76,133.31)
  BOTTOM w0.102: v2(133.76,133.31) 133.66,133.31 UV1.D16
  BOTTOM w0.112: v2(158.62,121.31) 158.31,121.62 UV15.E4
M_DA34: length 37.9
  IN3 w0.142: v2(132.51,131.86) 132.36,131.71 132.36,130.78 132.12,130.55 132.12,129.15 132.74,128.54 133.93,128.54 134.89,127.58 140.28,127.58 141.27,128.58 149.24,128.58 149.71,128.11 155.78,128.11 155.89,128 155.89,126.61 156.23,126.27 156.23,120.35 156.88,119.71 v2(157.11,119.71)
  BOTTOM w0.102: v2(132.51,131.86) 132.17,132.2 UV1.F15
  BOTTOM w0.127: UV15.F2 v2(157.11,119.71)
M_DA35: length 37.8
  IN3 w0.142: v2(132.81,131.39) 132.89,131.39 134.3,129.98 134.59,129.98 136.35,128.22 137.33,128.22 137.55,128 138.01,128 138.22,128.22 140.35,128.22 141.1,128.97 148.19,128.97 148.2,128.98 154.1,128.98 154.5,128.57 156.05,128.57 156.71,127.91 156.71,120.32 156.92,120.11 157.5,120.11 v2(157.91,119.71)
  BOTTOM w0.102: UV1.A15 134.41,132.06 134.06,132.06 133.78,131.78 133.21,131.78 v2(132.81,131.39)
  BOTTOM w0.127: UV15.E2 v2(157.91,119.71)
M_DA36: length 38.4
  IN3 w0.142: v2(135.61,132.6) 136.47,131.73 138.91,131.73 139.51,132.33 156.16,132.33 156.38,132.1 159.14,132.1 160.74,130.5 160.74,122.53 v2(160.33,122.12)
  BOTTOM w0.102: UV1.D14 133.68,131.4 134.13,131.85 134.86,131.85 v2(135.61,132.6)
  BOTTOM w0.112: v2(160.33,122.12) 160.33,122.08 UV15.B4
M_DA37: length 47.4
  IN3 w0.142: v2(136.2,132.57) 137.38,133.75 151.81,133.75 152.36,134.3 160.13,134.3 163.02,131.41 163.02,120.62 162.11,119.71 v2(161.11,119.71)
  BOTTOM w0.127: UV15.A2 v2(161.11,119.71) ; 136.2,132.32 134.83,130.95 132.83,130.95 132.48,130.6 UV1.F13
  BOTTOM w0.14: 136.2,132.32 v2(136.2,132.57)
M_DA38: length 40
  IN3 w0.142: v2(137.35,132.58) 137.35,132.35 137.55,132.15 138.73,132.15 139.33,132.75 155.71,132.75 155.99,133.03 158.48,133.03 158.76,132.75 159.75,132.75 161.83,130.67 161.83,121.96 v2(161.19,121.32)
  BOTTOM w0.102: UV1.A13 134.8,130.6 136.09,131.89 136.58,131.89
  BOTTOM w0.112: UV15.A4 161.51,121.63 v2(161.19,121.32)
  BOTTOM w0.14: 136.58,131.89 136.88,131.89 137.35,132.36 v2(137.35,132.58)
M_DA39: length 44.7
  IN3 w0.142: v2(160.31,119.71) 160.71,120.11 161.44,120.11 161.65,120.33 161.65,121.04 162.34,121.72 162.34,131.13 159.75,133.71 153.22,133.71 152.83,133.32 138.68,133.32 v2(137.96,132.6)
  BOTTOM w0.102: UV1.C13 134.15,130.19 134.8,130.19 136.04,131.43 136.58,131.43
  BOTTOM w0.127: UV15.B2 v2(160.31,119.71)
  BOTTOM w0.14: 136.58,131.43 137.08,131.43 137.96,132.3 v2(137.96,132.6)
M_DA40: length 34.4
  IN1 w0.145: v2(133.74,129.52) 134.67,130.46 136.58,130.46
  IN1 w0.147: v2(160.33,126.93) 160.35,126.94 160.35,127.64 160.74,128.03 160.74,130.44 160.31,130.86 160.31,131.15 159.36,132.1 157.44,132.1 157.15,132.39 143.44,132.39 141.5,130.46 136.58,130.46
  BOTTOM w0.102: v2(133.74,129.52) 133.73,129.52 133.46,129.52 UV1.E11
  BOTTOM w0.112: v2(160.33,126.93) UV15.B11
M_DA41: length 37.7
  IN1 w0.147: v2(161.15,126.94) 161.14,126.95 161.14,126.96 162.59,128.42 162.59,131.68 159.79,134.49 155.27,134.49 155.08,134.68 141.08,134.68 139.43,133.03 139.43,132.93 138.51,132.01 138.29,132.01 137.5,131.22 v2(137.5,131)
  BOTTOM w0.112: UV15.A11 v2(161.15,126.94)
  BOTTOM w0.127: UV1.A11 134.59,129.05 135.55,129.05
  BOTTOM w0.14: v2(137.5,131) v1(136.81,130.3) 135.55,129.05
M_DA42: length 36.7
  IN1 w0.147: v2(138.08,131) 138.08,131.2 138.45,131.57 138.92,131.57 141.45,134.09 154.97,134.09 155.01,134.06 159.61,134.06 162.14,131.53 162.14,129.47 v2(161.14,128.48)
  BOTTOM w0.102: 136.58,128.7 136.44,128.57 136.09,128.57 135.87,128.79 134.77,128.79 134.67,128.69 134.41,128.69 134.11,129 UV1.C11
  BOTTOM w0.112: UV15.B13 v2(161.14,128.48)
  BOTTOM w0.14: 136.58,128.7 v1(136.87,128.99) 138.08,130.21 v2(138.08,131)
M_DA43: length 36.5
  IN1 w0.145: v2(161.15,129.26) 161.65,129.76 161.65,130.33
  IN1 w0.147: v2(139.26,130.98) 141.93,133.65 159.27,133.65 161.65,131.26 161.65,130.33
  BOTTOM w0.102: UV1.F11 132.26,128.88 132.58,128.88 132.77,128.69 133.07,128.69 133.17,128.79 133.47,128.79 133.57,128.69 134.13,128.69 134.33,128.49 134.95,128.49 135,128.54 135.83,128.54 136.29,128.08 136.58,128.08
  BOTTOM w0.112: UV15.A13 v2(161.15,129.26)
  BOTTOM w0.14: v2(139.26,130.98) v1(139.26,130.28) 139.26,130.14 137.21,128.08 136.58,128.08
M_DA44: length 25.7
  IN1 w0.147: v2(157.98,126.93) 157.11,126.93 156.79,127.25 155.22,127.25 155.17,127.29 148.79,127.29 148.74,127.34 147.37,127.34 147.23,127.2 147.23,126.7 147.09,126.56 146.68,126.56 146.36,126.88 146,126.88 145.86,126.73 145.86,126.5 145.71,126.35 137.63,126.35 v2(136.83,127.15)
  BOTTOM w0.102: UV1.A9 134.57,127.42 136.03,127.42
  BOTTOM w0.112: UV15.E11 158.31,127.26 v2(157.98,126.93)
  BOTTOM w0.14: v2(136.83,127.15) 136.3,127.15 136.03,127.42
M_DA45: length 26.3
  IN1 w0.145: 148.19,128.92 154.51,128.92 154.63,128.8 156.51,128.8 156.63,128.91 157.48,128.91 v2(157.89,129.33)
  IN1 w0.147: 148.19,128.92 145.92,128.92 144.64,127.64 138.5,127.64 v2(138.01,127.15)
  BOTTOM w0.102: UV1.C9 133.74,127.4 134,127.14 134.36,127.14 134.41,127.09 135.93,127.09 136.47,126.55
  BOTTOM w0.112: v2(157.89,129.33) UV15.E13
  BOTTOM w0.127: 136.47,126.55 136.58,126.55
  BOTTOM w0.14: v2(138.01,127.15) 137.41,126.55 136.58,126.55
M_DA46: length 28.2
  IN1 w0.145: v2(157.96,127.72) 157.59,128.09 156.68,128.09 156.65,128.11 148.34,128.11
  IN1 w0.147: 148.34,128.11 145.75,128.11 144.62,126.98 139.78,126.98 139.62,127.14 v2(139.19,127.14)
  BOTTOM w0.102: 136.58,126.07 136.44,126.07 135.61,126.89 134.33,126.89 134.28,126.94 132.97,126.94 132.51,127.4 UV1.F9
  BOTTOM w0.112: v2(157.96,127.72) 157.55,127.31 UV15.F11
  BOTTOM w0.14: v2(139.19,127.14) 139.19,127.03 138.23,126.07 136.58,126.07
M_DA47: length 26.8
  IN1 w0.145: 148,129.76 154.8,129.76 155.24,129.32 v2(157.1,129.32)
  IN1 w0.147: v2(135.58,125.91) 135.58,126.51 137.16,128.09 144.17,128.09 144.36,128.29 144.37,128.29 145.85,129.76 148,129.76
  BOTTOM w0.102: UV1.D8 133.71,126.6 134.01,126.29 134.48,126.29 134.86,125.91 135.58,125.91 v2(135.58,125.91)
  BOTTOM w0.112: UV15.F13 v2(157.1,129.32)
M_DA48: length 21.3
  IN3 w0.142: v2(133.35,125.51) 132.94,125.1 132.94,124.18 132.83,124.06 132.83,121.99 134.06,120.76 145.15,120.76 146.22,119.69 v2(148.29,119.69)
  BOTTOM w0.112: UV15.U2 v2(148.29,119.69)
  BOTTOM w0.127: UV1.E7 133.23,125.51 v2(133.35,125.51)
M_DA49: length 22.3
  IN3 w0.142: v2(152.29,119.69) 151.89,120.08 151.89,122.32 149.88,124.33 138.02,124.33 137.84,124.51 v2(136.05,124.51)
  BOTTOM w0.112: UV15.M2 v2(152.29,119.69)
  BOTTOM w0.127: UV1.A7 134.54,125.65 134.77,125.43 135.23,125.43 136.05,124.61 136.05,124.52 v2(136.05,124.51)
M_DA50: length 22.4
  IN3 w0.142: v2(135.5,124.61) 135.5,124.39 135.78,124.1 136.84,124.1 137.09,123.85 149.77,123.85 151.09,122.52 151.09,121.85 151.49,121.45 v2(151.49,119.69)
  BOTTOM w0.112: UV15.N2 v2(151.49,119.69)
  BOTTOM w0.127: UV1.C7 134.07,125.8 135.26,124.61 v2(135.5,124.61)
M_DA51: length 23.2
  IN3 w0.142: v2(149.09,119.69) 148.5,119.1 146.25,119.1 145.03,120.32 133.74,120.32 132.56,121.5 132.56,123.5 132.01,124.05 132.01,124.95 v2(132.44,125.38)
  BOTTOM w0.112: UV15.T2 v2(149.09,119.69)
  BOTTOM w0.127: v2(132.44,125.38) 132.14,125.69 UV1.F7
M_DA52: length 17.4
  IN3 w0.142: v2(134.87,123.84) 134.68,123.66 134.68,122.77 135.87,121.57 147.74,121.57 148.28,122.11 v2(149.04,122.11)
  BOTTOM w0.102: UV1.A5 134.87,123.87 v2(134.87,123.84)
  BOTTOM w0.112: UV15.T4 149.1,122.11 v2(149.04,122.11)
M_DA53: length 26.3
  IN3 w0.142: v2(152.31,121.31) 152.7,121.7 152.7,123.6 152.38,123.92 151.01,123.92 149.36,125.56 140.34,125.56 140.06,125.84 136.13,125.84 135.71,125.42 135.04,125.42 133.28,123.67 v2(133.28,123.01)
  BOTTOM w0.102: v2(133.28,123.01) 133.28,123.87 132.96,124.2 UV1.E5
  BOTTOM w0.112: UV15.M4 v2(152.31,121.31)
M_DA54: length 22.4
  IN3 w0.142: v2(134.18,122.96) 134.18,124.07 135.23,125.12 136.18,125.12 136.46,125.4 139.84,125.4 140.42,124.81 149.77,124.81 152.29,122.28 v2(152.29,122.12)
  BOTTOM w0.102: UV1.C3 v2(134.18,122.96)
  BOTTOM w0.112: UV15.N4 151.91,121.72 152.29,122.1 v2(152.29,122.12)
M_DA55: length 16.6
  IN3 w0.142: v2(148.31,121.31) 148.17,121.17 134.46,121.17 133.38,122.25 v2(133.29,122.25)
  BOTTOM w0.102: v2(133.29,122.25) UV1.E1
  BOTTOM w0.112: UV15.U4 v2(148.31,121.31)
M_DA56: length 38.8
  BOTTOM w0.089: 136.49,121.54 136.27,121.33 132.15,121.33 131.77,121.71
  BOTTOM w0.102: 131.77,121.71 131.77,122.31 131.85,122.39 131.85,122.81 131.84,122.82 131.84,123.93 131.85,123.94 131.85,124.73 131.74,124.84 131.74,125.4 UV1.G7
  BOTTOM w0.127: 153.91,130.4 153.91,129.63 153.62,129.34 153.46,129.34 153.12,128.99 153.12,127.71 152.71,127.31 UV15.M11
  BOTTOM w0.14: 136.49,121.54 139.64,124.69 139.64,126.47 140.72,127.55 140.72,128.01 v1(144.41,131.71) 146.66,133.96 151.18,133.96 153.91,131.23 153.91,130.4
M_DA57: length 35.1
  BOTTOM w0.089: 137.19,120.56 137.14,120.5 132,120.5 131.06,121.44 131.06,121.91
  BOTTOM w0.102: 131.06,121.91 131.04,121.94 131.04,122.73 131.04,122.74 131.04,122.78 131.05,122.79 131.05,123.21 131.04,123.22 131.04,123.27 131,123.31 131,123.61 131.19,123.8 131.43,123.8 131.64,124.02 131.64,124.41 131.34,124.71 UV1.G6
  BOTTOM w0.127: UV15.N11 151.67,127.55 151.67,127.55 151.51,127.71 151.51,130.13
  BOTTOM w0.14: 151.51,130.13 151.51,130.46 151.52,130.47 151.52,131.1 150.43,132.19 147.42,132.19 v1(143.97,128.74) 141.06,125.83 141.06,124.42 137.19,120.56
M_DA58: length 31.5
  BOTTOM w0.089: 131.29,121.54 132.01,120.82 136.77,120.82 136.94,120.99
  BOTTOM w0.127: UV15.N13 152.3,129.3 152.3,130.4 ; UV1.G1 131.29,122.55 131.29,121.54
  BOTTOM w0.14: 152.3,130.4 152.3,131.31 150.73,132.88 v1(148.9,132.88) 147.31,132.88 140.6,126.17 140.6,124.65 136.94,120.99
M_DA59: length 33.7
  BOTTOM w0.089: 131.52,121.63 132.08,121.07 136.44,121.07 136.58,121.21
  BOTTOM w0.102: UV1.G3 131.34,123.12 131.51,122.95 131.51,122.86 131.64,122.72 131.64,122.47 131.52,122.34 131.52,121.86 131.51,121.84 131.51,121.66 131.52,121.65 131.52,121.63
  BOTTOM w0.127: 153.12,130.4 153.12,129.64 152.71,129.23 UV15.M13
  BOTTOM w0.14: 136.58,121.21 140.08,124.72 140.08,126.29 141.16,127.36 141.16,127.83 v1(146.18,132.85) 146.85,133.52 150.99,133.52 153.12,131.39 153.12,130.4
M_DA60: length 28.5
  BOTTOM w0.089: 130.53,120.55 131.48,119.61 138.02,119.61 139,120.59
  BOTTOM w0.102: UV1.J6 129.84,124.9 129.84,124.55 130.04,124.34 130.04,124.04 130.02,124.01 130.02,123.58 130.06,123.55 130.06,123.22 130.02,123.18 130.02,122.79 130.04,122.77 130.04,122.47 129.83,122.26 129.83,121.25 130.53,120.55
  BOTTOM w0.14: UV15.T13 149.11,129.31 148.44,129.31 v1(146.28,127.14) 141.54,122.4 140.81,122.4 139,120.59
M_DA61: length 25.6
  BOTTOM w0.089: 129.63,120.91 131.24,119.3 138.33,119.3 139,119.96
  BOTTOM w0.102: UV1.J1 129.63,122.49 129.63,120.91
  BOTTOM w0.14: UV15.U13 147.76,127.96 147.76,127.64 v1(142.82,122.7) 142.07,121.95 140.99,121.95 139,119.96
M_DA62: length 26.6
  BOTTOM w0.089: 129.58,120.65 129.92,120.31 129.92,119.81 130.82,118.91 138.58,118.91 139,119.33
  BOTTOM w0.102: 129.58,120.65 129.43,120.81 129.43,122.72 129.52,122.81 129.52,123.17 UV1.J3
  BOTTOM w0.14: 139,119.33 141.18,121.51 142.43,121.51 v1(144.62,123.7) 147.7,126.79 147.7,126.94 148.07,127.31 UV15.U11
M_DA63: length 29.6
  BOTTOM w0.089: 129.23,122.4 129.23,120.37 129.42,120.18 129.42,119.64 130.59,118.47 138.76,118.47 139,118.7
  BOTTOM w0.102: UV1.J5 129.74,124.14 129.2,123.6 129.2,123.21 129.27,123.14 129.27,122.85 129.21,122.78 129.21,122.42 129.23,122.4
  BOTTOM w0.127: 147.36,125.8 148.75,125.8 149.13,126.18 149.13,126.93 UV15.T11
  BOTTOM w0.14: 139,118.7 141.36,121.06 142.63,121.06 v1(146.4,124.84) 147.36,125.8
M_DBIA0: length 46.5
  IN3 w0.142: v2(130.26,142.19) 130.56,142.49 130.57,142.49 131.05,142.96 131.05,144.96 131.56,145.47 133.03,145.47 134.67,147.1 136.32,147.1 137.36,148.15 142.3,148.15 143.29,149.14 156.71,149.14 157.63,148.22 159.01,148.22 159.91,147.32 159.91,143.52 159.97,143.46 159.97,142.76 159.68,142.47 159.68,139.87 159.91,139.64 159.91,137.12 v2(159.51,136.73)
  BOTTOM w0.127: v2(130.26,142.19) 130.28,142.19 130.28,142.06 UV1.H27 ; UV13.D2 v2(159.51,136.73)
M_DBIA1: length 29.4
  IN1 w0.145: 135.31,142.73 135.23,142.65 135.23,142.28 135.2,142.25 v2(135.2,141.85)
  IN1 w0.147: 135.31,142.73 139.33,146.75 155.29,146.75 155.55,146.49 155.55,145.54 155.95,145.14 159.12,145.14 v2(159.51,145.53)
  BOTTOM w0.112: v2(159.51,145.53) 159.11,145.92 UV13.D13
  BOTTOM w0.127: v2(135.2,141.85) 135.15,141.8 UV1.A27
M_DBIA2: length 19.2
  IN3 w0.142: v2(150.71,136.73) 150.31,137.12 150.31,137.73 150.11,137.93 149.74,137.93 149.74,137.92 148.93,137.92 148.58,138.27 147.4,138.27 147.09,137.96 136.71,137.96 135.85,138.82 134.96,138.82 134.89,138.89 v2(134.12,138.89)
  BOTTOM w0.112: UV13.P2 151.11,137.12 v2(150.71,136.73)
  BOTTOM w0.127: v2(134.12,138.89) 133.83,138.6 UV1.C23
M_DBIA3: length 25.2
  BOTTOM w0.102: 136.1,136.32 136.08,136.32 134.97,135.21 134.83,135.21 134.7,135.08 134.41,135.08 134.33,135.16 133.98,135.16 UV1.C19 ; UV13.P13 150.69,146.34 150.14,146.34 149.84,146.65 149.84,147.01
  BOTTOM w0.127: 136.1,136.32 136.15,136.32 ; 149.68,147.42 149.77,147.33 149.77,147.08 149.84,147.01
  BOTTOM w0.14: 136.15,136.32 136.23,136.41 138.66,136.41 v1(141.58,139.34) 143.75,141.5 143.75,143.75 147.75,147.75 149.35,147.75 149.68,147.42
M_DBIA4: length 38.6
  IN3 w0.142: v2(134.13,132.51) 135.24,131.4 135.24,130.86 136.35,129.75 139.84,129.75 140.84,130.75 155.54,130.75 155.74,130.55 158.33,130.55 159.1,129.78 159.1,121.14 158.71,120.75 v2(158.71,119.71)
  BOTTOM w0.127: UV15.D2 v2(158.71,119.71) ; UV1.C15 133.82,132.2 v2(134.13,132.51)
M_DBIA5: length 29.5
  IN1 w0.145: v2(133.33,127.68) 133.73,127.28 135.21,127.28
  IN1 w0.147: 135.21,127.28 136.67,128.74 143.89,128.74 144.09,128.94 144.1,128.94 145.94,130.79 154.8,130.79 155.85,129.73 159.08,129.73 v2(159.51,129.31)
  BOTTOM w0.102: UV1.E9 133.23,127.68 v2(133.33,127.68)
  BOTTOM w0.112: v2(159.51,129.31) 159.11,128.91 UV15.D13
M_DBIA6: length 20.3
  IN3 w0.142: v2(150.72,120.49) 150.28,120.94 150.28,122.31 150,122.59 149.52,122.59 148.93,123.17 136.65,123.17 v2(136.24,123.58)
  BOTTOM w0.102: v2(136.24,123.58) 135.7,124.13 135.44,124.13 134.86,124.71 134.33,124.71 133.82,124.2 UV1.C5
  BOTTOM w0.112: UV15.P2 v2(150.72,120.49)
M_DBIA7: length 30.5
  BOTTOM w0.089: 130.83,121.87 130.83,121.54 130.83,121.35 132,120.18 137.28,120.18 137.32,120.23
  BOTTOM w0.102: 130.83,121.87 130.83,122.82 130.84,122.82 130.84,122.86 130.85,122.87 130.85,123.12 130.84,123.13 130.84,123.18 130.79,123.23 130.79,123.54 UV1.H4
  BOTTOM w0.127: UV15.P13 150.69,129.32
  BOTTOM w0.14: 137.32,120.23 141.51,124.42 141.51,124.62 141.73,124.84 141.73,125.4 143.78,127.44 143.78,127.45 v1(146.1,129.78) 147.83,131.51 150.09,131.51 150.6,131 150.6,130.44 150.6,130.44 150.6,130.3 150.61,130.29 150.61,129.9 150.65,129.85 150.65,129.37 150.69,129.32
M_EDCA0: length 52
  IN3 w0.142: v2(160.31,136.73) 160.71,137.13 160.71,147.63 159.23,149.12 157.97,149.12 157.06,150.03 142.42,150.03 142.11,149.71 142.11,149.21 141.93,149.04 141.58,149.04 141.41,149.21 141.41,149.75 141.23,149.93 140.88,149.93 140.71,149.75 140.71,149.21 140.53,149.04 140.18,149.04 140,149.21 140,149.74 139.83,149.91 139.48,149.91 139.3,149.74 139.3,149.21 139.13,149.04 138.78,149.04 138.6,149.21 138.6,149.76 138.43,149.94 138.06,149.94 137.87,149.75 137.87,149.21 137.7,149.04 137,149.04 135.95,147.99 133.49,147.99 130.53,145.03 130.53,143.27 v2(130.24,142.97)
  BOTTOM w0.127: UV13.C2 v2(160.31,136.73) ; UV1.H28 130.54,142.67 v2(130.24,142.97)
M_EDCA1: length 32.6
  IN1 w0.145: v2(134.26,142.19) 134.52,142.45 134.52,143.05 134.69,143.21 134.69,143.57 135.06,143.94
  IN1 w0.147: v2(159.51,146.33) 159.11,145.93 157.31,145.93 155.28,147.96 143.05,147.96 142.9,147.81 142.9,147.68 142.75,147.53 142.46,147.53 142.31,147.68 142.31,147.81 142.16,147.96 141.87,147.96 141.72,147.81 141.72,147.68 141.57,147.53 141.28,147.53 141.13,147.68 141.13,147.81 140.98,147.96 140.69,147.96 140.54,147.81 140.54,147.68 140.39,147.53 140.1,147.53 139.95,147.68 139.95,147.81 139.8,147.96 139.43,147.96 137.81,146.34 137.61,146.34 137.58,146.37 137.37,146.37 137.12,146.11 137.12,145.9 137.14,145.88 137.14,145.67 136.89,145.41 136.68,145.41 136.65,145.44 136.44,145.44 136.19,145.18 136.19,144.98 136.22,144.95 136.22,144.74 135.41,143.94 135.06,143.94
  BOTTOM w0.112: UV13.C13 159.91,145.93 v2(159.51,146.33)
  BOTTOM w0.127: UV1.C27 134.11,142.17 134.24,142.17 v2(134.26,142.19)
M_EDCA2: length 20.5
  IN3 w0.142: v2(135.61,138.36) 136.12,137.85 136.12,137.29 136.51,136.91 136.71,136.91 136.97,137.17 137.28,137.17 137.54,136.91 137.85,136.91 138.11,137.17 138.41,137.17 138.68,136.91 138.98,136.91 139.25,137.17 139.55,137.17 139.82,136.91 140.12,136.91 140.38,137.17 140.69,137.17 140.95,136.91 141.26,136.91 141.52,137.17 141.83,137.17 142.09,136.91 142.4,136.91 142.66,137.17 142.97,137.17 143.23,136.91 143.53,136.91 143.8,137.17 144.1,137.17 144.37,136.91 144.67,136.91 144.94,137.17 145.24,137.17 145.5,136.91 145.81,136.91 146.07,137.17 146.38,137.17 146.64,136.91 147.14,136.91 147.72,137.49 149.14,137.49 v2(149.91,136.73)
  BOTTOM w0.102: v2(149.91,136.73) 150.31,137.12 UV13.R2
  BOTTOM w0.14: v2(135.61,138.36) 135.9,138.64 135.9,138.84 135.73,139.01 135.49,139.01 135.42,138.93 134.88,138.93 UV1.A23
M_EDCA3: length 24.5
  BOTTOM w0.102: 135.45,134.98 134.88,134.98 134.76,134.86 134.34,134.86 134.29,134.91 133.04,134.91 132.94,135.02 UV1.E19
  BOTTOM w0.127: UV13.R13 150.05,145.93 149.71,146.26 148.43,146.26 ; 135.45,134.98 136.06,135.59
  BOTTOM w0.14: 136.06,135.59 v1(138.08,135.59) 138.93,135.59 139.29,135.95 139.59,135.95 139.9,136.26 139.9,136.56 140.21,136.87 140.51,136.87 140.81,137.17 140.81,137.47 144.62,141.28 144.62,143.41 147.7,146.49 148.2,146.49 148.43,146.26
M_EDCA4: length 41.9
  IN3 w0.142: v2(159.51,119.71) 159.91,120.11 159.91,130.01 159.74,130.18 159.74,130.35 158.76,131.33 156.06,131.33 155.83,131.55 139.85,131.55 139.68,131.39 139.68,130.69 139.52,130.53 136.12,130.53 135.91,130.74 135.91,131 136.14,131.22 136.14,131.54 135.95,131.73 135.44,131.73 134.59,132.58 134.59,132.81 134.34,133.06 134.08,133.06 133.53,132.52 v2(133.36,132.52)
  BOTTOM w0.102: UV1.E15 133.26,132.52 v2(133.36,132.52)
  BOTTOM w0.127: UV15.C2 v2(159.51,119.71)
M_EDCA5: length 32.1
  IN1 w0.145: 135,128.56 v2(134.13,127.69) ; v2(160.33,129.33) 159.55,130.12 159.55,130.4
  IN1 w0.147: 159.55,130.4 159.55,130.7 158.93,131.32 157.11,131.32 156.83,131.61 145.55,131.61 144.89,130.95 144.69,130.95 144.3,131.34 144.09,131.34 143.89,131.14 143.89,130.93 144.28,130.54 144.28,130.34 143.74,129.8 143.74,129.8 143.54,129.6 136.04,129.6 135,128.56
  BOTTOM w0.102: UV1.D10 133.54,128.2 134.05,127.69 v2(134.13,127.69)
  BOTTOM w0.112: UV15.C13 v2(160.33,129.33)
M_EDCA6: length 21.3
  IN3 w0.142: v2(149.92,120.49) 149.45,120.97 149.45,122.31 149.22,122.54 147.74,122.54 147.57,122.37 136.44,122.37 135.67,123.15 v2(135.67,123.58)
  BOTTOM w0.102: UV1.D6 133.2,124.86 133.2,124.36 133.44,124.12 133.44,124.07 133.61,123.89 133.87,123.89 134.24,124.26 134.24,124.32 134.41,124.5 134.77,124.5 135.53,123.75 135.53,123.72 v2(135.67,123.58)
  BOTTOM w0.112: UV15.R2 v2(149.92,120.49)
M_EDCA7: length 30.6
  BOTTOM w0.089: 137.65,120.05 137.6,119.99 131.76,119.99 130.05,121.71
  BOTTOM w0.102: UV1.G5 131.24,124.1 130.41,124.1 130.22,123.91 130.22,123.67 130.26,123.63 130.26,123.13 130.22,123.1 130.22,122.88 130.25,122.86 130.25,122.39 130.05,122.19 130.05,121.71
  BOTTOM w0.127: 149.77,130.4 149.77,129.97 149.96,129.78 149.96,129.25 UV15.R13
  BOTTOM w0.14: 137.65,120.05 v1(139.89,122.28) 140.78,123.17 141.21,123.17 143.56,125.52 143.56,126.07 148.18,130.69 149.52,130.69 149.77,130.43 149.77,130.4
M_MAA0_0: length 44.6
  TOP w0.102: 154.07,137.93 154.16,137.93 155.36,139.13 v2(155.51,139.13)
  TOP w0.127: 135.01,135.45 134.79,135.23 131.85,135.23 131.76,135.32 131.04,135.32 130.91,135.44 v2(130.91,135.69)
  TOP w0.14: 135.01,135.45 139.9,135.45 140.06,135.61 140.06,137.41 140.2,137.55 140.48,137.55 140.62,137.41 140.62,135.38 140.76,135.24 141.13,135.24 141.26,135.36 141.26,137.47 141.34,137.55 141.76,137.55 141.86,137.45 141.86,135.35 141.97,135.24 142.37,135.24 142.49,135.35 142.49,137.35 142.75,137.61 v1(146.69,137.61) 148.85,137.61 149.17,137.93 149.37,137.93 149.51,138.07 149.51,138.55 149.65,138.69 149.93,138.69 150.07,138.55 150.07,138.07 150.21,137.93 150.49,137.93 150.63,138.07 150.63,138.55 150.77,138.69 151.05,138.69 151.19,138.55 151.19,138.07 151.33,137.93 151.61,137.93 151.75,138.07 151.75,138.53 151.89,138.67 152.17,138.67 152.31,138.53 152.31,138.07 152.44,137.93 152.71,137.93 152.85,138.07 152.85,138.51 152.99,138.65 153.27,138.65 153.41,138.51 153.41,138.07 153.55,137.93 154.07,137.93
  BOTTOM w0.112: v2(155.51,139.13) 155.91,138.73 UV13.H4
  BOTTOM w0.127: v2(130.91,135.69) 130.51,135.69 130.17,135.35 130.17,134.6 129.93,134.37 129.59,134.37 129.22,134 UV1.K17
M_MAA0_1: length 41.2
  TOP w0.102: v2(130.91,136.83) 130.91,137.28 131.47,137.83 131.68,137.83 132.28,137.23 132.81,137.23 132.98,137.4 132.98,137.55 133.31,137.89 134.15,137.89
  TOP w0.127: 135.31,138.97 135.06,138.97 134.82,138.73 134.66,138.73 134.53,138.6 134.53,138.15 134.27,137.89 134.15,137.89
  TOP w0.14: 135.31,138.97 137.94,138.97 138.93,139.96 140.78,139.96 141.83,141.01 143.84,141.01 144.31,141.48 v1(145.61,141.48) 147.52,141.48 148.11,142.07 159.63,142.07 159.91,141.79 159.91,140.25 159.19,139.53 156.32,139.53 155.9,139.94 v2(155.9,140.09)
  BOTTOM w0.112: UV13.H5 155.91,140.08 v2(155.9,140.09)
  BOTTOM w0.127: v2(130.91,136.83) 130.97,136.77 130.97,136.29 130.72,136.03 130.39,136.03 130.02,136.4 UV1.J20
M_MAA0_2: length 41.3
  TOP w0.127: 134.66,141.16 133.43,139.94 132.32,139.94 131.91,139.53 131.31,139.53 131.17,139.67 131.17,139.94 131.08,140.03 130.65,140.03 130.55,139.92 130.55,138.76 130.4,138.6 129.9,138.6 129.78,138.48 129.78,137.68 129.93,137.53 130.41,137.53 130.54,137.66 130.54,137.91 v2(130.34,138.1)
  TOP w0.14: v2(156.29,143.91) 156.13,143.75 154.66,143.75 154.09,144.32 153.7,144.32 153.26,144.76 152.84,144.76 152.48,145.13 151.99,145.13 151.85,145.27 151.85,145.88 151.71,146.02 151.43,146.02 151.3,145.88 151.3,145.27 151.16,145.13 150.45,145.13 150.31,145.27 150.31,145.92 150.17,146.06 149.89,146.06 149.75,145.92 149.75,145.21 149.61,145.07 149.33,145.07 149.19,145.21 149.19,145.92 149.05,146.06 148.77,146.06 148.63,145.92 148.63,145.23 148.5,145.09 148.26,145.09 148.12,145.23 148.12,145.63 147.98,145.77 147.7,145.77 147.56,145.63 147.56,145.27 147.42,145.13 147.31,145.13 146.36,144.17 142.28,144.17 141.99,143.89 140.39,143.89 139.1,142.59 v1(138.9,142.59) 138.87,142.62 135.9,142.62 135.53,142.25 134.77,142.25 134.66,142.14 134.66,141.16
  BOTTOM w0.112: v2(156.29,143.91) 155.91,144.3 UV13.H11
  BOTTOM w0.127: v2(130.34,138.1) 130.51,138.1 130.85,138.44 130.85,138.6 130.78,138.66 130.61,138.66 UV1.H23
M_MAA0_3: length 40.5
  TOP w0.127: 135.31,139.87 134.54,139.87 134.41,139.73 134.21,139.73 133.06,138.58 132.42,138.58 132.07,138.23 v2(131.74,138.23)
  TOP w0.14: v2(155.91,142.96) 156.48,143.53 158.21,143.53 158.22,143.53 161.76,143.53 161.93,143.35 161.93,142.64 161.67,142.38 148.07,142.38 147.66,141.96 144.11,141.96 143.64,141.49 141.63,141.49 140.58,140.44 138.62,140.44 v1(138.14,139.96) 137.63,139.46 135.74,139.46 135.66,139.53 135.66,139.54 135.43,139.77 135.42,139.77 135.32,139.87 135.31,139.87
  BOTTOM w0.102: UV1.G23 131.37,138.6 v2(131.74,138.23)
  BOTTOM w0.112: v2(155.91,142.96) 155.91,142.96 UV13.H10
M_MAA0_4: length 39.9
  TOP w0.127: v2(131.78,139.02) 132.47,139.71 133.54,139.71 134.69,140.86
  TOP w0.14: 134.69,140.86 135.32,140.86 135.46,141 135.46,141.51 135.6,141.65 135.88,141.65 136.02,141.51 136.02,141 136.16,140.86 136.49,140.86 136.63,141 136.63,141.53 136.77,141.67 137.05,141.67 137.19,141.53 137.19,141 137.33,140.86 137.68,140.86 137.88,141.07 137.88,142.02 138,142.13 138.37,142.13 138.51,142 138.51,141.54 138.65,141.4 138.92,141.4 139.06,141.54 139.06,141.74 139.2,141.88 139.48,141.88 139.62,141.74 139.62,141.54 139.76,141.4 140.04,141.4 140.18,141.54 140.18,141.74 140.32,141.88 140.67,141.88 141.23,142.45 141.64,142.45 141.78,142.59 141.78,143.24 141.92,143.38 142.2,143.38 142.34,143.24 142.34,142.59 142.48,142.45 142.78,142.45 142.95,142.62 142.95,143.52 143.1,143.67 143.48,143.67 143.58,143.57 143.58,143.01 143.67,142.93 144.02,142.93 144.11,143.02 144.11,143.55 144.25,143.69 144.53,143.69 144.67,143.55 144.67,143.07 144.81,142.93 145.12,142.93 145.26,143.07 v1(145.26,143.29) 145.26,143.55 145.4,143.69 145.68,143.69 145.82,143.55 145.82,143.07 145.96,142.93 146.23,142.93 146.37,143.07 146.37,143.5 146.75,143.89 147.36,143.89 147.49,144.02 147.49,144.52 147.62,144.64 148.1,144.64 148.24,144.51 148.24,144.38 148.3,144.33 150.22,144.33 150.36,144.19 150.36,143.81 150.5,143.67 150.94,143.67 151.08,143.81 151.08,144.57 151.22,144.71 151.78,144.71 151.92,144.57 151.92,143.9 152.06,143.76 152.43,143.76 152.57,143.9 152.57,144.42 152.67,144.52 153.12,144.52 153.73,143.91 v2(153.9,143.91)
  BOTTOM w0.112: UV13.K11 v2(153.9,143.91)
  BOTTOM w0.127: v2(131.78,139.02) 131.82,139.06 131.82,139.37 131.71,139.49 131.43,139.49 131.34,139.4 UV1.G24
M_MAA0_5: length 40.6
  TOP w0.127: v2(131.01,139.02) 130.78,138.79 130.78,138.56 131,138.35 131.26,138.35 131.54,138.62 131.98,138.62 132.17,138.81 132.96,138.81 134.22,140.06 134.29,140.06 134.61,140.38
  TOP w0.14: v2(153.89,143.11) 153.89,142.74 154,142.63 154.27,142.63 154.41,142.77 154.41,142.97 154.55,143.11 154.83,143.11 154.97,142.97 154.97,142.77 155.11,142.63 155.4,142.63 155.51,142.74 155.51,143.42 155.42,143.51 153.64,143.51 153.63,143.52 152.76,143.52 152.63,143.38 152.63,142.83 152.49,142.69 152.21,142.69 152.07,142.83 152.07,143.38 151.93,143.52 151.13,143.52 150.99,143.38 150.99,142.83 150.85,142.69 150.57,142.69 150.43,142.83 150.43,143.38 150.29,143.52 149.03,143.52 148.86,143.68 148.86,143.79 148.73,143.93 148.08,143.93 147.94,143.79 147.94,143.4 148.08,143.26 148.6,143.26 148.74,143.12 148.74,142.86 148.58,142.71 148.06,142.71 147.8,142.45 147.55,142.45 147.41,142.58 147.41,143.26 147.27,143.4 146.99,143.4 146.85,143.26 146.85,142.58 146.71,142.45 143.91,142.45 143.44,141.97 141.43,141.97 v1(140.71,141.25) 140.38,140.92 138.42,140.92 137.88,140.38 134.61,140.38
  BOTTOM w0.102: UV1.H24 130.2,139.4 130.11,139.49 130.11,139.75 130.19,139.84 130.91,139.84 131.01,139.73 v2(131.01,139.02)
  BOTTOM w0.112: UV13.K10 v2(153.89,143.11)
